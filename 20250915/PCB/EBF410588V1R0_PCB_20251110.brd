# Allegro board EBF410588V1R0_PCB_20251110.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MIPI_DPHY_DSI_TX_D2P: length 90.5
  TOP w0.084: v1(130.25,28.54) 130.37,28.67 arc(130.5,28.76) 130.65,28.79 130.75,28.79 arc(130.92,28.72) 131,28.54 131,27 arc(131.12,26.36) 131.49,25.81 133.56,23.74 arc(134.11,23.37) 134.75,23.25 136.42,23.25 arc(136.56,23.22) 136.68,23.14 138.47,21.34 arc(138.93,21.04) 139.46,20.93 140.73,20.93 arc(140.81,20.92) 140.87,20.88 140.94,20.81 arc(141.06,20.73) 141.21,20.7 142.45,20.7 arc(142.54,20.68) 142.62,20.63 142.63,20.62 arc(142.7,20.56) 142.8,20.55 J13.17 ; CN3.10 77.52,49.42 arc(77.51,49.48) 77.48,49.53 77.47,49.54 arc(77.43,49.59) 77.42,49.65 77.42,49.8 arc(77.37,50.06) 77.22,50.28 77.05,50.46 arc(77,50.53) 76.99,50.6 76.99,50.85 arc(76.96,50.97) 76.9,51.07 76.64,51.33 arc(76.55,51.45) 76.52,51.61 v1(76.52,51.79)
  ART03 w0.076: v1(130.25,28.54) 130.12,28.67 arc(129.99,28.75) 129.84,28.78 arc(129.84,28.78) 129.84,28.78 124.4,28.78 arc(123.82,28.9) 123.32,29.23 115.1,37.45 arc(114.77,37.94) 114.66,38.53 114.66,39.37 arc(114.27,40.3) 113.33,40.69 97.65,40.69 arc(97.07,40.81) 96.57,41.14 95.74,41.97 arc(95.55,42.1) 95.32,42.14 95.13,42.14 arc(94.99,42.12) 94.88,42.04 v1(94.77,41.93)
  BOTTOM w0.084: v1(76.52,51.79) 76.52,51.6 arc(76.49,51.44) 76.4,51.31 76.18,51.08 arc(76.05,50.89) 76,50.66 76,48.21 arc(76.16,47.41) 76.62,46.72 77.59,45.76 arc(77.71,45.57) 77.75,45.36 77.75,44 arc(77.88,43.36) 78.24,42.82 78.9,42.15 arc(79.45,41.79) 80.09,41.66 87.39,41.66 arc(87.99,41.78) 88.51,42.12 88.57,42.19 arc(89.02,42.49) 89.55,42.6 90.79,42.6 arc(90.97,42.56) 91.12,42.46 91.19,42.39 arc(91.4,42.25) 91.66,42.2 94.32,42.2 arc(94.54,42.15) 94.72,42.03 94.77,41.99 v1(94.77,41.93)
MIPI_DPHY_DSI_TX_D3N: length 90.5
  TOP w0.084: CN3.4 76.32,49.42 arc(76.33,49.48) 76.37,49.53 76.38,49.54 arc(76.41,49.59) 76.42,49.65 76.42,49.71 arc(76.4,49.81) 76.35,49.9 75.94,50.3 arc(75.87,50.41) 75.85,50.53 75.85,50.67 arc(75.82,50.75) 75.74,50.79 v1(75.52,50.79) ; v1(135.99,30.32) 135.99,30.02 arc(136.02,29.95) 136.09,29.93 137.17,29.93 arc(137.81,29.8) 138.36,29.43 140.79,27 arc(140.91,26.92) 141.05,26.89 142.45,26.89 arc(142.54,26.91) 142.62,26.96 142.63,26.98 arc(142.7,27.03) 142.8,27.05 J13.30
  ART03 w0.076: v1(93.22,41.54) 93.22,41.38 arc(93.24,41.26) 93.31,41.15 93.33,41.14 arc(93.44,41.07) 93.57,41.04 94.3,41.04 arc(94.88,40.92) 95.37,40.59 95.55,40.42 arc(95.98,40.13) 96.48,40.03 110.81,40.03 arc(111.39,39.91) 111.88,39.58 123.12,28.35 arc(123.54,28.07) 124.05,27.97 131.96,27.97 arc(132.47,28.07) 132.9,28.35 133.98,29.43 arc(134.47,29.76) 135.05,29.88 135.73,29.88 arc(135.88,29.91) 136.01,29.99 136.02,30 arc(136.08,30.15) 136.02,30.3 v1(135.99,30.32)
  BOTTOM w0.084: v1(93.22,41.54) 93.22,41.53 arc(93.3,41.35) 93.22,41.18 93.18,41.14 arc(93.13,41.1) 93.06,41.09 92.76,41.09 arc(92.71,41.11) 92.69,41.16 arc(92.67,41.2) 92.62,41.22 92.42,41.22 arc(92.38,41.2) 92.36,41.16 arc(92.34,41.11) 92.29,41.09 92.09,41.09 arc(92.04,41.11) 92.02,41.16 arc(92,41.2) 91.95,41.22 91.75,41.22 arc(91.7,41.2) 91.68,41.16 arc(91.66,41.11) 91.62,41.09 91.2,41.09 arc(91.12,41.12) 91.08,41.21 91.08,41.53 arc(90.67,41.94) 90.26,41.53 90.26,41.3 arc(90.2,41.15) 90.05,41.09 89.97,41.09 arc(89.88,41.12) 89.84,41.21 89.84,41.63 arc(89.44,42.04) 89.03,41.63 89.03,41.3 arc(88.97,41.15) 88.82,41.09 79.77,41.09 arc(79.2,41.2) 78.72,41.52 77.36,42.88 arc(77.04,43.36) 76.93,43.92 76.93,44.62 arc(76.8,45.27) 76.44,45.81 75.27,46.98 arc(75.24,47.02) 75.23,47.07 75.23,47.23 arc(75.25,47.27) 75.3,47.29 arc(75.34,47.31) 75.36,47.35 75.36,47.56 arc(75.34,47.61) 75.3,47.62 arc(75.25,47.64) 75.23,47.69 75.23,47.9 arc(75.25,47.94) 75.3,47.96 arc(75.34,47.98) 75.36,48.02 75.36,48.23 arc(75.34,48.28) 75.3,48.3 arc(75.25,48.31) 75.23,48.36 75.23,48.57 arc(75.25,48.61) 75.3,48.63 arc(75.34,48.65) 75.36,48.69 75.36,48.9 arc(75.34,48.95) 75.3,48.97 arc(75.25,48.98) 75.23,49.03 75.23,49.24 arc(75.25,49.28) 75.3,49.3 arc(75.34,49.32) 75.36,49.36 75.36,49.57 arc(75.34,49.62) 75.3,49.64 arc(75.25,49.66) 75.23,49.7 75.23,49.91 arc(75.25,49.95) 75.3,49.97 arc(75.34,49.99) 75.36,50.04 75.36,50.24 arc(75.34,50.29) 75.3,50.31 arc(75.25,50.33) 75.23,50.37 75.23,50.67 arc(75.27,50.75) 75.35,50.79 v1(75.52,50.79)
MIPI_DPHY_DSI_TX_D3P: length 90.4
  TOP w0.084: J13.29 142.8,26.55 arc(142.7,26.56) 142.63,26.62 142.62,26.63 arc(142.54,26.68) 142.45,26.7 141.05,26.7 arc(140.83,26.74) 140.65,26.86 138.22,29.29 arc(137.74,29.61) 137.17,29.73 136.49,29.73 arc(136.3,29.69) 136.14,29.59 v1(135.99,29.43) ; v1(75.52,51.79) 75.52,51.6 arc(75.55,51.44) 75.64,51.31 75.9,51.05 arc(76.01,50.89) 76.05,50.7 76.05,50.53 arc(76.06,50.48) 76.08,50.44 76.49,50.04 arc(76.59,49.89) 76.62,49.71 76.62,49.65 arc(76.63,49.59) 76.67,49.54 76.68,49.53 arc(76.71,49.48) 76.72,49.42 CN3.6
  ART03 w0.076: v1(93.22,40.65) 93.32,40.75 arc(93.42,40.81) 93.54,40.84 94.29,40.84 arc(94.8,40.74) 95.23,40.45 95.4,40.27 arc(95.9,39.94) 96.48,39.83 110.81,39.83 arc(111.31,39.73) 111.74,39.44 122.97,28.21 arc(123.47,27.88) 124.05,27.76 131.96,27.76 arc(132.55,27.88) 133.04,28.21 134.12,29.29 arc(134.55,29.57) 135.05,29.67 135.59,29.67 arc(135.74,29.64) 135.87,29.56 v1(135.99,29.43)
  BOTTOM w0.084: v1(93.22,40.65) 93.04,40.82 arc(92.97,40.87) 92.87,40.89 91.2,40.89 arc(90.98,40.98) 90.88,41.21 90.88,41.53 arc(90.67,41.74) 90.46,41.53 90.46,41.3 arc(90.34,41.01) 90.05,40.89 89.97,40.89 arc(89.74,40.98) 89.65,41.21 89.65,41.63 arc(89.44,41.84) 89.23,41.63 89.23,41.3 arc(89.11,41.01) 88.82,40.89 79.77,40.89 arc(79.13,41.02) 78.58,41.38 77.22,42.74 arc(76.86,43.28) 76.73,43.92 76.73,44.62 arc(76.62,45.19) 76.3,45.67 75.13,46.84 arc(75.06,46.94) 75.04,47.07 75.04,50.72 arc(75.08,50.94) 75.2,51.12 75.41,51.33 arc(75.49,51.46) 75.52,51.61 v1(75.52,51.79)
ON/OFF: length 12.4
  BOTTOM w0.152: SW3.2 143.23,70.61 142.93,70.31 142.93,68.38 142.62,68.07 D13.2 140.44,68.07 139.78,68.73 138.32,68.73 137.66,68.08 C30.1 137.58,68.07 136.97,68.68 135.86,68.68 R31.1
PCIE0_CLKREQN_M0: length 113
  TOP w0.102: CN2.26 57.12,50.09 57.43,50.39 57.43,51.28 v1(56.92,51.79)
  ART03 w0.097: v1(56.92,51.79) 56.89,51.79 56.41,51.31 56.41,48.51 55.22,47.32 55.22,46.66 54.43,45.87 54.43,26.9 55.63,25.7 55.63,15.34 57.56,13.41 58.39,13.41 58.7,13.11 58.7,12.52 60.1,11.13 60.1,10.41 61.26,9.25 61.82,9.25 64.35,6.72 64.35,4.17 63.78,3.6 63.78,2.75 64.45,2.08 93.22,2.08 97.76,6.63 107.11,6.63 108.03,7.54 v1(108.03,9.7)
  BOTTOM w0.102: v1(108.03,9.7) 108.69,10.36 R181.1
PCIE0_PERSTN: length 110.1
  TOP w0.152: v1(93.5,29.08) 57.76,29.08 v1(56.67,27.99) ; v1(110.53,17.28) 112.23,17.28 113.34,16.17 119.32,16.17 120.19,17.04 120.19,22.07 121.12,23 123.55,23 R183.2 ; v1(57.92,50.79) 57.92,50.28 57.52,49.88 CN2.28
  ART03 w0.152: v1(110.53,17.28) 110.18,17.63 97.18,17.63 93.5,21.31 v1(93.5,29.08) ; v1(56.67,27.99) 55.65,29.01 55.65,41.81 56.33,42.49 56.33,46.17 57.45,47.29 57.45,50.32 v1(57.92,50.79)
PCIE0_REFCLKN: length 64.4
  TOP w0.084: CN4.44 60.72,11.61 arc(60.73,11.55) 60.77,11.5 60.78,11.49 arc(60.81,11.44) 60.82,11.39 60.82,10.99 arc(60.92,10.51) 61.19,10.11 61.71,9.59 arc(61.89,9.47) 62.11,9.42 70.55,9.42 arc(70.79,9.37) 71,9.24 72.84,7.4 arc(72.93,7.34) 73.04,7.32 75.79,7.32 arc(76.33,7.42) 76.79,7.73 76.86,7.8 arc(77.25,8.06) 77.72,8.15 108.24,8.15 arc(108.44,8.19) 108.61,8.31 108.96,8.66 arc(109.39,8.94) 109.89,9.04 111.17,9.04 arc(111.64,9.24) 111.84,9.71 111.84,11.56 arc(111.94,12.1) 112.25,12.55 112.26,12.57 arc(112.72,12.87) 113.26,12.98 116.51,12.98 arc(116.65,12.95) 116.77,12.87 116.78,12.86 arc(116.86,12.74) 116.89,12.6 116.89,12.55 arc(116.85,12.37) 116.76,12.23 116.73,12.2 arc(116.63,12.04) 116.59,11.85 J20.11
PCIE0_REFCLKP: length 64.4
  TOP w0.084: J20.13 117.39,11.85 arc(117.35,12.04) 117.24,12.2 117.2,12.24 arc(117.12,12.37) 117.09,12.53 117.09,12.6 arc(117.04,12.82) 116.92,13 116.91,13.01 arc(116.73,13.13) 116.51,13.18 113.26,13.18 arc(112.64,13.06) 112.12,12.71 112.11,12.69 arc(111.76,12.17) 111.64,11.56 111.64,9.71 arc(111.5,9.38) 111.17,9.24 109.89,9.24 arc(109.31,9.13) 108.82,8.8 108.47,8.45 arc(108.37,8.38) 108.24,8.35 77.72,8.35 arc(77.18,8.24) 76.72,7.94 76.65,7.87 arc(76.26,7.61) 75.79,7.51 73.04,7.51 arc(73.01,7.52) 72.98,7.54 71.14,9.38 arc(70.87,9.56) 70.55,9.62 62.11,9.62 arc(61.97,9.65) 61.85,9.73 61.33,10.25 arc(61.1,10.59) 61.02,10.99 61.02,11.39 arc(61.03,11.44) 61.07,11.49 61.08,11.5 arc(61.11,11.55) 61.12,11.61 CN4.46
PCIE0_RXN: length 77.2
  TOP w0.127: J20.23 124.59,11.78 arc(124.62,11.95) 124.72,12.09 124.76,12.14 arc(124.83,12.25) 124.86,12.38 124.86,12.45 arc(124.84,12.54) 124.79,12.62 124.71,12.7 arc(124.57,12.79) 124.4,12.83 121.2,12.83 arc(121.05,12.8) 120.92,12.71 120.24,12.03 arc(120.15,11.9) 120.12,11.74 120.12,9.34 arc(119.94,8.48) 119.45,7.75 119.43,7.72 arc(118.7,7.23) 117.83,7.06 117,7.06 arc(116.88,7.04) 116.77,6.97 115.65,5.85 arc(114.83,5.3) 113.86,5.11 69.73,5.11 arc(68.76,5.3) 67.94,5.85 66.04,7.75 arc(65.93,7.82) 65.8,7.85 61.28,7.85 arc(60.3,8.04) 59.48,8.59 58.86,9.21 arc(58.62,9.57) 58.54,9.98 58.54,10.28 arc(58.57,10.45) 58.67,10.59 58.74,10.66 arc(58.78,10.72) 58.8,10.79 58.8,11.41 58.72,11.49 CN4.34
PCIE0_RXP: length 77.2
  TOP w0.127: CN4.36 59.12,11.49 59.05,11.41 59.05,10.79 arc(59.02,10.63) 58.92,10.48 58.85,10.41 arc(58.81,10.35) 58.79,10.28 58.79,9.98 arc(58.86,9.66) 59.04,9.39 59.66,8.77 arc(60.4,8.28) 61.28,8.1 65.8,8.1 arc(66.03,8.06) 66.22,7.93 68.12,6.03 arc(68.86,5.53) 69.73,5.36 113.86,5.36 arc(114.73,5.53) 115.47,6.03 116.59,7.15 arc(116.78,7.27) 117,7.32 117.83,7.32 arc(118.6,7.47) 119.25,7.9 119.27,7.93 arc(119.71,8.58) 119.86,9.34 119.86,11.74 arc(119.91,11.99) 120.06,12.21 120.74,12.89 arc(120.95,13.03) 121.2,13.08 124.4,13.08 arc(124.67,13.03) 124.89,12.88 124.97,12.8 arc(125.08,12.64) 125.11,12.45 125.11,12.4 arc(125.15,12.24) 125.24,12.1 125.26,12.08 arc(125.35,11.94) 125.39,11.77 J20.25
PCIE0_TXN: length 75.8
  TOP w0.127: CN4.38 59.52,11.49 59.6,11.41 59.6,10.91 arc(59.63,10.75) 59.72,10.61 59.8,10.53 arc(59.84,10.47) 59.85,10.4 59.85,9.83 arc(60.18,9.02) 60.99,8.69 65.83,8.69 arc(66.7,8.51) 67.44,8.02 68.24,7.22 arc(69.06,6.67) 70.03,6.48 113.02,6.48 arc(114,6.67) 114.82,7.22 115.58,7.98 arc(116.13,8.35) 116.78,8.48 117.7,8.48 arc(117.8,8.46) 117.88,8.4 v1(118.13,8.16) ; v1(127.69,6.39) 127.88,6.57 arc(127.98,6.72) 128.02,6.9 128.02,6.93 arc(127.98,7.11) 127.88,7.26 C170.1
  ART03 w0.127: v1(127.69,6.39) 127.86,6.56 arc(127.98,6.72) 128.02,6.92 128.02,7.26 arc(127.66,8.13) 126.79,8.48 118.59,8.48 arc(118.48,8.46) 118.38,8.4 118.14,8.16 v1(118.13,8.16)
PCIE0_TXP: length 75.7
  TOP w0.127: C171.1 128.41,7.26 arc(128.31,7.11) 128.27,6.93 128.27,6.9 arc(128.31,6.72) 128.41,6.57 v1(128.59,6.39) ; CN4.40 59.92,11.49 59.85,11.41 59.85,10.91 arc(59.86,10.84) 59.9,10.79 59.98,10.71 arc(60.07,10.57) 60.1,10.4 60.1,9.83 arc(60.36,9.2) 60.99,8.94 65.83,8.94 arc(66.8,8.75) 67.62,8.2 68.42,7.4 arc(69.16,6.91) 70.03,6.73 113.02,6.73 arc(113.9,6.91) 114.64,7.4 114.64,7.4 115.4,8.16 arc(116.03,8.58) 116.78,8.73 117.7,8.73 arc(117.8,8.75) 117.88,8.81 v1(118.13,9.05)
  ART03 w0.127: v1(128.59,6.39) 128.42,6.56 arc(128.31,6.72) 128.27,6.92 128.27,7.26 arc(127.84,8.3) 126.79,8.74 118.74,8.74 arc(118.46,8.79) 118.23,8.95 v1(118.13,9.05)
PCIE0_WAKEN_M0: length 109.9
  TOP w0.152: v1(56.92,50.79) 56.72,50.59 CN2.24
  ART03 w0.152: v1(64.35,3.17) 64.85,3.67 64.85,7.34 62.33,9.86 61.37,9.86 60.6,10.62 60.6,11.33 59.21,12.73 59.21,13.31 56.53,15.99 56.53,25.54 55.04,27.03 55.04,42.16 55.45,42.57 55.45,46.02 55.85,46.43 55.85,47.04 56.92,48.11 v1(56.92,50.79)
  BOTTOM w0.152: v1(64.35,3.17) 64.35,2.17 65.25,1.27 104.19,1.27 109.12,6.2 112.78,6.2 114.17,7.59 R180.1
PE_TXN: length 2.6
  TOP w0.127: J20.31 127.79,9.94 arc(127.82,9.77) 127.92,9.63 127.93,9.62 arc(128.03,9.47) 128.06,9.31 128.06,9.19 arc(128.01,8.95) 127.87,8.74 C170.2
PE_TXP: length 2.6
  TOP w0.127: C171.2 128.47,8.68 arc(128.36,8.85) 128.31,9.06 128.31,9.31 arc(128.35,9.47) 128.44,9.61 128.46,9.63 arc(128.55,9.77) 128.59,9.94 J20.33
PMIC_EXT_EN: length 19.3
  TOP w0.152: v1(48.9,9.18) 49.94,8.13 57.2,8.13 57.92,8.85 CN4.30
  BOTTOM w0.152: v1(48.9,9.18) 48.36,9.71 48.36,14.19 R199.1
PWM0_CH0_M0_IR: length 129.2
  TOP w0.152: CN2.33 58.72,45.11 58.44,44.83 58.44,43.6 v1(58.92,43.11) ; R26.1 R21.2 141.05,8.97 147.35,8.97 147.65,9.27 147.65,14.64 v1(145.32,16.97)
  ART03 w0.152: v1(145.32,16.97) 145.32,19.2 144.96,19.56 140.92,19.56 139.62,18.26 137.49,18.26 136.19,19.56 132.03,19.56 130,21.59 122.71,21.59 122.22,21.11 98.04,21.11 96.01,23.14 96.01,32.78 v1(96.5,33.27)
  BOTTOM w0.152: v1(58.92,43.11) 58.88,43.07 58.88,39.52 59.72,38.68 61.72,38.68 66.64,33.76 96.02,33.76 v1(96.5,33.27)
PWM2_CH3_M3: length 63.1
  TOP w0.152: CN3.68 89.12,50.01 89.52,50.41 v1(89.52,50.79)
  ART03 w0.152: J32.11 143.87,51.61 139.75,47.5 111.43,47.5 107.44,51.49 97.51,51.49 94.46,48.44 91.62,48.44 89.52,50.53 v1(89.52,50.79)
PWM2_CH6_M3: length 68.1
  TOP w0.152: CN3.66 88.72,50.06 89.03,50.37 89.03,51.29 v1(89.52,51.79)
  ART03 w0.152: v1(89.52,51.79) 89.54,51.79 90.02,51.31 90.02,50.77 91.97,48.82 94.19,48.82 97.32,51.94 107.63,51.94 111.62,47.96 139.4,47.96 144.2,52.76 145.87,52.76 J32.10
PWM2_CH7_M3: length 73.5
  TOP w0.152: CN3.64 88.32,50.1 88.52,50.3 v1(88.52,50.79)
  ART03 w0.152: J32.8 148.34,55.63 148.34,51.49 147.37,50.52 143.69,50.52 140.23,47.07 111.25,47.07 107.26,51.05 97.69,51.05 94.64,48.01 91.3,48.01 v1(88.52,50.79)
PWR_3V3_EN: length 46
  TOP w0.152: CN2.27 57.52,44.4 57.43,44.3 57.43,43.61 v1(57.92,43.11)
  ART03 w0.152: v1(61.64,11.18) 62.12,11.66 64.16,11.66 64.8,12.29 65.92,12.29 66.95,13.33 66.95,14.27 66.57,14.66 66.57,15.47 62.61,19.43 62.61,28.35 57.51,33.45 57.51,39.27 58.34,40.11 58.34,42.32 57.92,42.74 v1(57.92,43.11)
  BOTTOM w0.152: R195.1 60.33,10.87 60.64,11.18 v1(61.64,11.18)
PWR_5V_EN: length 68.8
  TOP w0.152: CN2.25 57.12,44.31 v1(56.92,44.11)
  ART03 w0.152: v1(56.92,44.11) 57.33,43.71 57.33,41.94 56.36,40.98 56.36,33.63 62.15,27.84 62.15,19.08 66.17,15.06 66.17,14.48 66.47,14.17 66.47,13.67 66.24,13.44 64.39,13.44 64.08,13.13 64.08,12.4 63.83,12.14 61.42,12.14 61.11,11.84 61.11,10.92 61.57,10.46 62.74,10.46 65.35,7.85 65.35,4.11 v1(66.22,3.25)
  BOTTOM w0.152: R200.1 75.87,6.54 75.87,3.23 75.54,2.9 66.57,2.9 v1(66.22,3.25)
PWR_12V_EN: length 71.7
  TOP w0.152: CN2.29 v1(57.92,44.11)
  ART03 w0.152: v1(92.86,33.27) 92.53,32.94 92.53,20.57 93.22,19.89 93.22,19.18 93.47,18.92 94.36,18.92 94.72,18.56 v1(94.72,16.51)
  BOTTOM w0.152: v1(57.92,44.11) 58.41,43.63 58.41,39.21 59.41,38.2 61.59,38.2 66.52,33.27 v1(92.86,33.27) ; R193.1 95.91,8.92 95.91,16.13 95.53,16.51 v1(94.72,16.51)
PWR_ON: length 205
  TOP w0.152: v1(40.37,10.63) 41.49,10.63 42.42,9.7 49.2,9.7 50.27,8.64 57.15,8.64 57.52,9.01 CN4.28 ; v1(19.68,48.39) 22.23,48.39 23.24,47.37 28.55,47.37 29.84,48.67 35.2,48.67 36.04,47.83 v1(39.67,47.83) ; v1(39.18,52.7) 40.18,53.7 48.67,53.7 49.63,52.73 61.82,52.73 62.4,53.3 82.61,53.3 83.21,53.9 v1(107.8,53.9)
  ART03 w0.152: v1(40.37,10.63) 39.7,11.3 39.7,18.87 42.06,21.23 42.06,24.1 43.97,26.01 43.97,40.64 39.67,44.93 v1(39.67,47.83) ; v1(134.05,67.08) 134.05,66.48 133.25,65.68 133.25,53.44 131.52,51.71 128.75,51.71 125.96,48.92 111.89,48.92 107.8,53.01 v1(107.8,53.9)
  BOTTOM w0.152: v1(39.18,52.7) 39.37,52.51 39.37,50.62 38.89,50.14 38.89,48.16 39.22,47.83 v1(39.67,47.83) ; v1(134.05,67.08) 134.05,67.39 134.25,67.59 R31.2 ; Q12.3 v1(19.68,48.39)
RECOVERY: length 15
  BOTTOM w0.152: SW2.2 144.45,75.62 142.19,73.36 142.19,70.21 141.71,69.72 D12.2 140.28,69.72 139.6,70.41 138.34,70.41 137.66,69.73 C27.1 137.58,69.72 137.02,70.28 135.81,70.28 R30.1
RECOVERY_KEY: length 125.8
  TOP w0.152: v1(133.05,66.08) 133.05,52.43 129.47,48.85 123.22,48.85 122.73,48.36 111.81,48.36 110.06,46.61 110.06,34.87 100.81,25.63 58.03,25.63 v1(56.67,26.99) ; v1(57.12,16.51) 57.12,16.33 57.52,15.93 CN4.27
  ART03 w0.152: v1(56.67,26.99) 57.63,26.02 57.63,17.02 v1(57.12,16.51)
  BOTTOM w0.152: R30.2 134.24,69.72 133.55,69.04 133.55,66.89 133.05,66.39 v1(133.05,66.08)
RK806_VDC: length 5.3
  TOP w0.152: v1(58.92,44.11) 58.92,44.54 59.52,45.14 CN2.37
  BOTTOM w0.152: R198.1 59.44,43.6 v1(58.92,44.11)
RMII0_AVDD33: length 25.8
  TOP w0.203: v1(56.9,65.29) 57.53,64.67 U7.11 ; U7.40 63.9,64.66 64.51,65.27 v1(64.84,65.27)
  TOP w0.254: R52.2 68.71,59.82 v1(68.78,59.74)
  ART03 w0.508: v1(68.78,59.74) 68.12,60.4 68.12,64.44 66.62,65.94 65.51,65.94 v1(64.84,65.27) 56.92,65.27 v1(56.9,65.29)
  BOTTOM w0.254: C48.1 64.12,65.27 v1(64.84,65.27) ; v1(56.9,65.29) 57.17,65.02 C46.1 C47.1 57.67,66.7 L5.2
RMII0_LED1: length 42.2
  TOP w0.152: v1(65.85,61.98) 65.36,61.49 64.62,61.49 64.25,61.87 U7.33
  BOTTOM w0.152: J6.14 54.63,86 51.97,83.34 51.97,75.21 57.4,69.77 65.05,69.77 65.79,69.04 65.79,66.47 66.65,65.61 66.65,62.78 v1(65.85,61.98) 64.83,62.99 R56.1
RMII0_LED2: length 54.2
  TOP w0.152: v1(64.85,61.98) 64.56,62.26 U7.34
  BOTTOM w0.152: R54.1 v1(64.85,61.98) 65.33,61.49 66.05,61.49 67.11,62.55 67.11,65.81 66.24,66.67 66.24,69.24 65.3,70.18 57.68,70.18 52.35,75.51 52.35,82.96 54.15,84.76 67.6,84.76 J6.11
RMII0_MDIN0: length 12.2
  TOP w0.084: U7.2 62.31,65.91 62.41,66.01 62.41,69.12 63.16,69.87 64.71,69.87 66.6,71.76 66.6,72.56 65.99,73.18 65.51,73.18 65.4,73.07 J6.3
RMII0_MDIN1: length 18.8
  TOP w0.084: U7.5 61.11,65.91 61.21,66.01 61.21,69.95 61.95,70.68 62.91,70.68 64.02,71.79 64.02,72.53 62.69,73.86 62.69,75.76 62.51,75.95 60.55,75.95 60.33,75.72 60.33,72.22 J6.7
RMII0_MDIN2: length 9.9
  TOP w0.084: J6.6 61.45,74.61 61.45,71.66 60.41,70.62 60.41,66.01 60.31,65.91 U7.7
RMII0_MDIN3: length 10
  TOP w0.084: U7.10 59.11,65.91 59.21,66.01 59.21,71.04 58.81,71.44 58.81,73.09 58.65,73.25 57.94,73.25 57.78,73.09 J6.9
RMII0_MDIP0: length 12.1
  TOP w0.084: U7.1 62.71,65.91 62.61,66.01 62.61,69.03 63.25,69.67 64.8,69.67 66.8,71.68 66.8,74.62 J6.2
RMII0_MDIP1: length 18.9
  TOP w0.084: U7.4 61.51,65.91 61.41,66.01 61.41,69.87 62.03,70.48 62.99,70.48 64.22,71.71 64.22,72.61 62.89,73.94 62.89,75.72 63.12,75.95 64.57,75.95 65.3,75.21 65.3,74.04 65,73.74 64.26,73.74 64.13,73.87 J6.4
RMII0_MDIP2: length 10
  TOP w0.084: J6.5 62.86,73.06 62.74,73.18 62.26,73.18 61.65,72.57 61.65,71.58 60.61,70.54 60.61,66.01 60.71,65.91 U7.6
RMII0_MDIP3: length 9.9
  TOP w0.084: U7.9 59.51,65.91 59.41,66.01 59.41,71.12 59.01,71.52 59.01,73.17 58.7,73.48 58.7,74.4 J6.8
RMII0_VDD10: length 9.4
  TOP w0.203: U7.38 64.43,63.86 v1(64.84,64.27) ; U7.8 v1(59.91,66.75) ; v1(58.04,59.21) 58.23,59.41 58.68,59.41 59.11,59.84 U7.21 ; U7.3 v1(61.91,66.75)
  TOP w0.254: C38.1 v1(65.74,54.86)
  BOTTOM w0.254: C40.1 61.85,66.69 v1(61.91,66.75) ; v1(58.04,59.21) 58.67,59.84 C39.1 ; C37.1 59.94,66.72 v1(59.91,66.75)
  vias: v1(65.74,55.88)
RMII1_AVDD33: length 33.7
  TOP w0.203: v1(83.25,65.27) 82.95,65.27 82.34,64.66 U8.40 ; v1(75.31,65.29) 75.94,64.67 U8.11
  TOP w0.254: R76.2 v1(87.17,59.82)
  ART03 w0.508: v1(75.31,65.29) 75.58,65.02 83,65.02 v1(83.25,65.27) 84.51,64.01 85.78,64.01 87.83,61.95 87.83,60.48 v1(87.17,59.82)
  BOTTOM w0.305: C64.1 82.61,65.27 v1(83.25,65.27) 83.25,66.66 82.19,67.72 77.15,67.72 L7.2 76.21,66.77 C63.1 C62.1 75.58,65.02 v1(75.31,65.29)
RMII1_LED1: length 50.3
  TOP w0.152: U8.33 82.61,61.87 82.98,61.49 83.77,61.49 v1(84.26,61.98)
  ART04 w0.152: v1(84.26,61.98) 86.31,64.03 86.31,69.95 87.12,70.76 89.18,70.76 89.48,71.07 89.48,73.61 93.8,77.93 93.8,82.37 91.44,84.73 76.9,84.73 J7.14
  BOTTOM w0.152: R80.1 82.61,62.74 83.44,62.74 84.2,61.98 v1(84.26,61.98)
RMII1_LED2: length 37.1
  TOP w0.152: v1(83.26,61.98) 82.97,62.26 U8.34
  ART04 w0.152: v1(83.26,61.98) 83.77,61.47 84.54,61.47 86.74,63.67 86.74,69.72 87.35,70.33 89.43,70.33 89.99,70.89 89.99,73.36 94.23,77.6 94.23,82.65 91.72,85.17 89.72,85.17 J7.11
  BOTTOM w0.152: R79.1 v1(83.26,61.98)
RMII1_MDIN0: length 13.5
  TOP w0.084: U8.2 80.72,65.91 80.82,66.01 80.82,68.55 82.09,69.82 84.68,69.82 86.54,71.68 86.54,72.74 86.1,73.18 85.52,73.18 85.44,73.09 J7.3
RMII1_MDIN1: length 19.4
  TOP w0.084: J7.7 80.37,72.22 80.37,75.56 80.57,75.77 82.58,75.77 82.76,75.59 82.76,74.01 84.1,72.66 84.1,71.76 82.98,70.63 81.63,70.63 79.62,68.62 79.62,66.01 79.52,65.91 U8.5
RMII1_MDIN2: length 10.6
  TOP w0.084: J7.6 81.63,71.76 78.82,68.96 78.82,66.01 78.72,65.91 U8.7
RMII1_MDIN3: length 10.3
  TOP w0.084: U8.10 77.52,65.91 77.62,66.01 77.62,69.39 79.04,70.82 79.04,72.57 78.41,73.2 77.93,73.2 77.82,73.09 J7.9
RMII1_MDIP0: length 13.5
  TOP w0.084: U8.1 81.12,65.91 81.02,66.01 81.02,68.47 82.17,69.62 84.76,69.62 86.74,71.6 86.74,72.82 86.49,73.08 86.49,74.53 J7.2
RMII1_MDIP1: length 19.5
  TOP w0.084: U8.4 79.92,65.91 79.82,66.01 79.82,68.54 81.71,70.43 83.06,70.43 84.3,71.68 84.3,72.75 82.96,74.09 82.96,75.51 83.21,75.77 84.96,75.77 85.24,75.49 85.24,74.09 84.89,73.74 84.3,73.74 84.17,73.87 J7.4
RMII1_MDIP2: length 10.7
  TOP w0.084: J7.5 82.9,73.08 82.77,73.21 82.41,73.21 81.83,72.63 81.83,71.68 79.02,68.87 79.02,66.01 79.12,65.91 U8.6
RMII1_MDIP3: length 10.1
  TOP w0.084: U8.9 77.92,65.91 77.82,66.01 77.82,69.31 79.24,70.73 79.24,72.65 79.02,72.87 79.02,74.68 J7.8
RMII1_VDD10: length 9.5
  TOP w0.203: U8.3 v1(80.32,66.75) ; v1(76.45,59.21) 76.64,59.41 77.09,59.41 77.52,59.84 U8.21 ; v1(83.25,64.27) 82.84,63.86 U8.38 ; U8.8 v1(78.32,66.75)
  TOP w0.254: C54.1 v1(84.15,54.86)
  BOTTOM w0.254: v1(76.45,59.21) 76.48,59.21 C56.1 ; v1(80.32,66.75) 80.21,66.64 C53.1 ; C55.1 78.43,66.64 v1(78.32,66.75)
  vias: v1(84.15,55.88)
ROUT1: length 6.8
  TOP w0.203: v1(47.85,59.69) 48.13,59.97 U9.11
  BOTTOM w0.203: C82.2 48.62,62.94 48.62,61.31 48.16,60.85 48.16,59.99 v1(47.85,59.69)
ROUT2: length 36.6
  TOP w0.203: C211.1 33.23,54.41 33.71,54.41 34.34,55.04 34.34,58.93 33.63,59.64 33.63,64.24 34.05,64.66 v1(34.88,64.66) ; v1(51.13,60.29) 50.56,60.87 U9.14
  BOTTOM w0.203: v1(51.13,60.29) 51.13,58.47 50.67,58.01 45.47,58.01 40.46,63.02 35.23,63.02 34.88,63.37 v1(34.88,64.66)
RS232_R1IN: length 50.6
  TOP w0.203: U33.13 18.28,28.68 18.69,28.27 24.28,28.27 25.48,27.08 25.48,25.81 26.42,24.87 v1(26.42,24.59)
  ART03 w0.203: J24.4 50.37,7.65 38.2,7.65 37.31,8.53 37.31,13.89 33.12,18.08 33.12,19 27.53,24.59 v1(26.42,24.59)
RS232_R1OUT: length 148.6
  TOP w0.152: U33.12 v1(19.56,29.05) ; v1(21.86,1.79) 22.75,2.68 117.03,2.68 117.79,3.44 117.79,5.32 118.6,6.13 126.18,6.13 126.64,5.66 126.64,3.78 127.03,3.4 131.92,3.4 J27.1
  ART03 w0.152: v1(21.86,1.79) 22.86,2.79 22.86,7.57 21.03,9.4 21.03,17.04 19.28,18.8 19.28,28.77 v1(19.56,29.05)
RS232_R2IN: length 59.9
  TOP w0.203: v1(57.43,3.89) 61.21,3.89 63.38,6.05 J24.1 ; U33.8 v1(23.36,24.58)
  ART03 w0.203: v1(57.43,3.89) 55.47,1.93 34.32,1.93 32.21,4.04 32.21,8 30.51,9.7 30.51,10.9 27.84,13.56 27.84,16 22.83,21.01 22.83,24.05 v1(23.36,24.58)
RS232_R2OUT: length 133.8
  TOP w0.152: v1(24.86,1.79) 24.89,1.75 117.37,1.75 119.07,3.45 123.91,3.45 J28.1 ; U33.9 v1(23.36,29.05)
  ART03 w0.152: v1(24.86,1.79) 24.86,7.88 22.66,10.08 22.66,17.85 20.78,19.73 20.78,26.47 v1(23.36,29.05)
RS232_T1IN: length 147.5
  TOP w0.152: v1(22.86,1.79) 23.34,2.27 117.23,2.27 118.26,3.3 118.26,5.16 118.8,5.69 125.96,5.69 126.26,5.38 126.26,3.58 126.8,3.05 131.88,3.05 J27.2 ; U33.11 v1(20.82,29.05)
  ART03 w0.152: v1(20.82,29.05) 19.78,28.01 19.78,19.11 21.62,17.27 21.62,9.65 23.5,7.77 23.5,2.42 v1(22.86,1.79)
RS232_T1OUT: length 46.2
  TOP w0.203: v1(25.42,24.59) 24.56,25.44 24.56,26.97 23.93,27.61 17.43,27.61 17.02,28.02 U33.14
  ART03 w0.203: v1(25.42,24.59) 25.42,24.22 33.2,16.43 33.2,13.49 35.41,11.28 35.41,7.37 38.02,4.75 43.05,4.75 J24.6
RS232_T2IN: length 134.8
  TOP w0.152: J28.2 123.83,3.05 119.28,3.05 117.53,1.3 24.35,1.3 v1(23.86,1.79) ; U33.10 v1(22.1,29.05)
  ART03 w0.152: v1(23.86,1.79) 24.13,2.06 24.13,7.86 22.12,9.86 22.12,17.63 20.24,19.51 20.24,27.19 v1(22.1,29.05)
RS232_T2OUT: length 53.3
  TOP w0.203: U33.7 v1(22.1,24.58)
  ART03 w0.203: v1(22.1,24.58) 22.1,25.13 22.62,25.64 23.98,25.64 24.38,25.24 24.38,21.72 25.3,20.8 26.44,20.8 30.86,16.38 30.86,13.54 33.45,10.95 33.45,5.36 35.51,3.3 53.03,3.3 J24.3
RS485_1_3V3: length 5.7
  TOP w0.381: L16.2 C198.1 39.37,13.54 v1(39.24,13.67) U36.8
  BOTTOM w0.254: D41.2 39.22,13.64 v1(39.24,13.67)
RS485_1_A: length 18.6
  TOP w0.203: U36.6 36.7,14.05 37.13,13.61 37.13,12.17 36.93,11.96 36.54,11.96 R211.2 ; R211.2 35.85,11.96 35.43,11.96 DN1.2 34.63,12.18 34.49,12.04 33.91,12.04 33.53,11.65 33.53,9.5 34.44,8.59 35.61,8.59 36.37,7.82 36.37,6.38 36.05,6.05 J31.2 ; R211.2 v1(36.2,13.08)
  BOTTOM w0.203: R213.1 v1(36.2,13.08)
RS485_1_B: length 18.6
  TOP w0.203: J31.1 37.03,6.05 36.73,6.35 36.73,7.97 35.76,8.94 34.59,8.94 33.88,9.65 33.88,11.48 34.09,11.68 34.4,11.68 34.63,11.44 DN1.1 35.38,11.61 35.9,11.61 R211.1 ; U36.7 37.97,14.1 37.54,13.67 37.54,12.07 37.08,11.61 36.49,11.61 R211.1 ; R211.1 v1(36.2,10.63)
  BOTTOM w0.203: R211.1 v1(36.2,10.63)
RS485_1_DIR: length 55.7
  TOP w0.152: CN2.4 52.72,49.54 52.42,49.84 51.07,49.84 48.22,52.7 41.19,52.7 v1(41.18,52.7) ; U36.3 36.7,20.98 36.96,21.23 37.64,21.23 37.84,21.43 ; 37.84,21.43 37.97,21.29 U36.2 ; 37.84,21.43 R212.1 37.84,22.69 v1(37.56,22.97)
  ART03 w0.152: v1(37.56,22.97) 38.03,23.44 40.61,23.44 43.43,26.26 43.43,40.54 39.14,44.83 39.14,51.38 39.95,52.2 40.68,52.2 v1(41.18,52.7)
RS485_2_3V3: length 5.4
  TOP w0.381: U37.8 v1(32.51,13.67)
  BOTTOM w0.254: v1(32.51,13.67) 32.49,13.64 D42.2
  BOTTOM w0.381: v1(32.51,13.67) C199.1 L17.2
RS485_2_A: length 17.3
  TOP w0.203: R216.2 v1(29.72,13.08) ; R216.2 29.72,12.29 30.05,11.96 30.33,11.96 30.53,12.17 30.53,13.36 29.97,13.92 U37.6 ; R216.2 29.4,11.99 28.93,11.99 DN2.2 28.16,12.19 27.95,11.99 27.42,11.99 27.01,11.58 27.01,9.06 28.73,7.35 28.73,6.4 28.38,6.05 J31.4
  BOTTOM w0.203: R215.1 v1(29.72,13.08)
RS485_2_B: length 17.3
  TOP w0.203: U37.7 31.24,13.72 30.89,13.36 30.89,12.02 30.47,11.61 30.01,11.61 R216.1 ; R216.1 29.45,11.58 28.88,11.58 DN2.1 28.16,11.47 27.99,11.63 27.57,11.63 27.37,11.43 27.37,9.21 29.08,7.49 29.08,6.25 29.29,6.05 J31.3 ; R216.1 v1(29.72,10.63)
  BOTTOM w0.203: R216.1 v1(29.72,10.63)
RS485_2_DIR: length 63.8
  TOP w0.152: v1(36.56,22.97) 36.04,22.45 31.59,22.45 R217.1 31.24,21.84 U37.2 31.24,18.87 30.96,18.59 30.28,18.59 29.97,18.9 U37.3 ; v1(40.18,52.7) 40.68,53.2 48.51,53.2 51.46,50.24 52.58,50.24 53.12,49.7 CN2.6
  ART03 w0.152: v1(36.56,22.97) 37.51,23.93 40.23,23.93 42.95,26.64 42.95,40.34 38.71,44.58 38.71,51.64 39.77,52.7 v1(40.18,52.7)
RTC_32K_IN: length 41
  TOP w0.152: v1(31.88,44.96) 32.74,44.09 36.88,44.09 37.8,43.18 37.8,41.73 38.79,40.74 58.52,40.74 59.05,41.27 60.93,41.27 62.44,42.78 62.44,44.66 63.12,45.34 CN2.55
  BOTTOM w0.152: v1(31.88,44.96) 31.88,46.87 R29.2
RTC_INT: length 44.2
  TOP w0.152: v1(27.69,45.21) 28.35,45.87 32.77,45.87 33.63,45.01 37.44,45.01 38.79,43.66 38.79,41.81 39.47,41.12 58.24,41.12 58.85,41.73 59.79,41.73 60.44,42.38 60.44,44.31 60.72,44.6 CN2.43
  BOTTOM w0.152: R156.2 26.75,47.68 D18.2 v1(27.69,45.21)
SAI1_LRCK_M0: length 88.5
  TOP w0.102: U9.7 45.62,61.51 v1(45.13,61.03) ; v1(88.72,19.51) 88.72,19.5 88.72,16.16 87.92,15.36 CN5.61
  ART03 w0.097: v1(45.13,61.03) 44.83,60.73 44.83,60.02 47.85,57 v1(47.85,30.25)
  BOTTOM w0.102: v1(47.85,30.25) 48.39,30.78 61.06,30.78 63.35,28.5 87.05,28.5 88.72,26.82 v1(88.72,19.51)
SAI1_MCLK_M0: length 89.7
  TOP w0.102: U9.1 v1(45.11,64.22) ; CN5.57 87.12,15.47 87.72,16.07 v1(87.72,18.51)
  ART03 w0.097: v1(45.11,64.22) 45.57,63.76 45.57,61.77 47.4,59.94 47.4,58.98 48.85,57.52 v1(48.85,30.25)
  BOTTOM w0.102: v1(87.72,18.51) 88.23,19.01 88.23,26.58 86.79,28.02 63.12,28.02 60.88,30.25 v1(48.85,30.25)
SAI1_SCLK_M0: length 90
  TOP w0.102: v1(44.13,62.03) 44.52,62.41 U9.5 ; CN5.59 87.52,15.41 88.23,16.11 88.23,19 v1(87.72,19.51)
  ART03 w0.097: v1(46.85,30.25) 46.85,56.45 43.66,59.64 43.66,61.56 v1(44.13,62.03)
  BOTTOM w0.102: v1(46.85,30.25) 47.41,29.69 60.71,29.69 62.82,27.58 86.39,27.58 87.72,26.25 v1(87.72,19.51)
SAI1_SDI0_M0: length 83.1
  TOP w0.152: v1(45.52,60.03) 46.48,60.03 46.78,60.33 U9.8 ; CN5.53 86.32,15.66 86.72,16.06 v1(86.72,18.51)
  ART03 w0.152: v1(45.52,60.03) 48.37,57.18 48.37,28.74 v1(48.85,28.25)
  BOTTOM w0.152: v1(48.85,28.25) 49.08,28.47 60.07,28.47 62.15,26.39 66.04,26.39 66.78,25.65 82.93,25.65 86.21,22.38 86.21,19.02 v1(86.72,18.51)
SAI1_SDO2_M0: length 86.8
  TOP w0.152: CN5.55 86.72,15.58 87.21,16.06 87.21,19.02 v1(86.72,19.51) ; U9.6 45.07,61.97 v1(44.13,61.03)
  ART03 w0.152: v1(47.85,28.25) 47.37,28.73 47.37,56.67 44.13,59.91 v1(44.13,61.03)
  BOTTOM w0.152: v1(47.85,28.25) 48.56,28.96 60.2,28.96 62.36,26.8 66.27,26.8 67.03,26.04 83.34,26.04 86.72,22.65 v1(86.72,19.51)
SARADC_IN3: length 106.7
  TOP w0.152: v1(59.92,51.79) 59.92,50.34 60.72,49.54 CN2.44
  ART03 w0.152: v1(107.16,9.12) 105.54,7.49 95.68,7.49 93.09,4.9 93.09,3.17 92.46,2.54 68.07,2.54 66.4,4.21 66.4,9.36 65.63,10.13 65.63,11.56 65.89,11.81 66.12,11.81 67.44,13.13 67.44,14.48 67.06,14.86 67.06,15.8 63.14,19.71 63.14,28.75 58.83,33.07 58.83,42.55 58.47,42.9 58.47,46.46 58.65,46.63 58.65,49.73 59.54,50.62 59.54,51.4 v1(59.92,51.79)
  BOTTOM w0.152: R207.1 106.89,9.39 v1(107.16,9.12) ; v1(59.92,51.79) 59.13,52.58 57.03,52.58 R16.1 R15.2
SARADC_IN5: length 98.2
  TOP w0.152: CN2.46 61.12,49.82 60.44,50.51 60.44,51.3 v1(60.92,51.79)
  ART03 w0.152: v1(60.92,51.79) 60.9,51.79 60.41,51.29 60.41,50.75 59.64,49.99 59.64,46.68 59.33,46.38 59.33,37.16 59.94,36.55 59.94,32.84 63.7,29.08 63.7,19.84 67.54,16 67.54,15.06 67.94,14.66 67.94,12.9 66.57,11.53 66.57,10.19 67.51,9.25 67.51,3.89 68.38,3.02 92.18,3.02 92.56,3.4 92.56,5.16 95.4,8 103.25,8 v1(104.37,9.12)
  BOTTOM w0.152: R208.1 104.1,9.39 v1(104.37,9.12)
SARADC_IN6: length 88.5
  TOP w0.152: CN2.48 61.52,49.96 60.92,50.56 v1(60.92,50.79)
  ART03 w0.152: v1(60.92,50.79) 60.92,50.58 60.17,49.83 60.17,46.48 59.82,46.13 59.82,41.1 60.5,40.41 60.5,33.2 64.26,29.44 64.26,20.02 68.02,16.26 68.02,15.32 68.45,14.88 68.45,12.37 67.61,11.53 67.61,10.41 68.12,9.91 68.12,5.97 69.57,4.52 90.22,4.52 94.21,8.51 100.97,8.51 v1(101.57,9.12)
  BOTTOM w0.152: v1(101.57,9.12) 101.3,9.39 R209.1
SARADC_IN7: length 86.9
  TOP w0.152: v1(61.92,51.79) 61.44,51.3 61.44,50.55 61.92,50.07 CN2.50
  ART03 w0.152: v1(98.78,9.12) 94.03,9.12 89.92,5 69.82,5 69.04,5.79 69.04,10.08 68.61,10.52 68.61,11.71 69.47,12.57 69.47,13.46 69.04,13.89 69.04,15.98 64.8,20.22 64.8,29.77 61.49,33.07 61.49,40.54 60.43,41.61 60.43,45.72 60.71,46 60.71,49.68 61.49,50.47 61.49,51.36 61.92,51.79 v1(61.92,51.79)
  BOTTOM w0.152: R210.1 98.51,9.39 v1(98.78,9.12)
SDMMC0_CLK: length 71.9
  TOP w0.102: CN5.35 82.72,15.36 83.01,15.65 83.01,22.02 84.05,23.06 100.14,23.06 v1(100.52,22.68)
  BOTTOM w0.102: R20.1 127.12,21.48 127.12,25.08 126.6,25.59 126.6,26.86 121.58,31.89 103.01,31.89 102.03,30.91 102.03,24.94 101.86,24.77 100.96,24.77 100.79,24.59 100.79,24.25 100.96,24.07 101.86,24.07 102.03,23.9 102.03,23.52 101.86,23.34 101.17,23.34 v1(100.52,22.68)
SDMMC0_CMD: length 72.3
  TOP w0.102: v1(101.52,21.53) 100.84,21.53 99.82,22.56 84.2,22.56 83.52,21.88 CN5.39
  BOTTOM w0.102: v1(101.52,21.53) 102.57,22.58 102.57,30.45 103.55,31.44 121.32,31.44 126.1,26.66 126.1,25.39 126.62,24.87 126.62,20.4 127.41,19.61 127.41,17.68 127.91,17.17 128.68,17.17 R19.1
SDMMC0_D0: length 71.5
  TOP w0.102: CN5.47 85.12,15.7 85.71,16.29 85.71,20.22 86.05,20.57 98.48,20.57 v1(99.52,19.53)
  BOTTOM w0.102: R23.1 127.62,22.5 127.62,25.33 127.11,25.85 127.11,27.12 121.89,32.34 102.16,32.34 101.22,31.39 101.22,27.14 101.05,26.97 100.22,26.97 100.05,26.8 100.05,26.45 100.22,26.28 101.1,26.28 101.27,26.11 101.27,25.83 101.1,25.65 100.3,25.65 100.02,25.37 100.02,22.18 100.19,22 100.74,22 100.91,21.83 100.91,21.49 100.74,21.31 100.19,21.31 100.02,21.14 100.02,19.88 99.67,19.53 v1(99.52,19.53)
SDMMC0_D1: length 71.6
  TOP w0.102: v1(99.52,20.53) 98.99,21.06 85.5,21.06 85.17,20.72 85.17,16.46 84.72,16.02 CN5.45
  BOTTOM w0.102: R24.1 128.13,23.39 128.13,25.59 127.61,26.11 127.61,27.33 122.1,32.84 100.47,32.84 99.52,31.89 99.52,31.27 99.69,31.1 100.23,31.1 100.41,30.93 100.41,30.58 100.23,30.41 99.69,30.41 99.52,30.24 99.52,29.89 99.69,29.72 100.23,29.72 100.41,29.55 100.41,29.2 100.23,29.03 99.69,29.03 99.52,28.85 99.52,28.51 99.69,28.34 99.93,28.34 100.1,28.16 100.1,27.82 99.93,27.65 99.69,27.65 99.52,27.47 v1(99.52,20.53)
SDMMC0_D2: length 71.9
  TOP w0.102: v1(101.52,19.53) 101.23,19.53 99.2,21.56 84.97,21.56 84.63,21.23 84.63,16.61 84.32,16.3 CN5.43
  BOTTOM w0.102: R17.1 128.37,15.24 126.4,17.21 126.4,19.07 125.61,19.85 125.61,24.4 125.09,24.92 125.09,26.24 120.8,30.53 104.37,30.53 103.53,29.69 103.53,21.55 v1(101.52,19.53)
SDMMC0_D3: length 71.9
  TOP w0.102: CN5.41 83.92,16.59 84.1,16.76 84.1,21.45 84.72,22.07 99.44,22.07 100.98,20.53 v1(101.52,20.53)
  BOTTOM w0.102: R18.1 128.09,16.26 126.9,17.44 126.9,19.4 126.12,20.19 126.12,24.61 125.6,25.13 125.6,26.45 121.06,30.98 104.06,30.98 103.07,30 103.07,22.09 v1(101.52,20.53)
SDMMC0_DETN: length 67.1
  TOP w0.152: v1(98.52,19.53) 97.98,20.07 86.51,20.07 86.21,19.76 86.21,16.23 85.52,15.55 CN5.49
  BOTTOM w0.152: R25.1 128.79,25.65 128.11,26.32 128.11,27.54 121.82,33.83 100.39,33.83 98.98,32.43 98.98,20 v1(98.52,19.53)
SIM_CLK0: length 29.6
  TOP w0.102: J20.12 116.99,20.26 117.12,20.4 117.12,22.96 118.69,24.54 123.04,24.54 127.08,28.57 127.08,33.3 129.62,35.84 129.62,38.07 v1(128.07,39.62)
  BOTTOM w0.102: R174.1 v1(128.07,39.62)
SIM_DATA0: length 28.4
  TOP w0.152: v1(128.06,37.2) 128.7,37.2 129.03,36.87 129.03,36.02 126.39,33.38 126.39,28.85 122.63,25.1 117.86,25.1 116.03,23.27 116.03,20.47 116.19,20.31 J20.10
  BOTTOM w0.152: v1(128.06,37.2) 128.06,36.92 R175.1
SIM_RST0: length 24.8
  TOP w0.152: J20.14 117.79,20.18 118.21,20.6 118.21,22.53 119.61,23.93 123.34,23.93 127.71,28.3 127.71,33.05 128.88,34.22 130.08,34.22 v1(130.63,34.76)
  BOTTOM w0.152: v1(130.63,34.76) 130.92,35.05 R173.1
SIM_VDD: length 36
  TOP w0.381: J20.8 115.39,24.53 117.27,26.42 122.66,26.42 125.58,29.34 125.58,33.72 v1(128.06,36.2)
  ART03 w0.305: v1(132.04,36.91) 132.07,36.88 132.66,36.88 v1(133.38,36.17)
  BOTTOM w0.305: J19.1 133.73,34.09 133.38,34.44 v1(133.38,36.17) ; v1(128.06,36.2) 128.06,35.89 128.36,35.59 129.29,35.59 129.79,36.09 R171.1 129.83,36.2 130.97,37.35 U27.1 131.74,37.35 132.04,37.04 v1(132.04,36.91)
SPI1_CLK_M0: length 108
  TOP w0.102: CN4.71 66.32,15.67 66.22,15.77 66.22,21.97 69.42,25.17 101.09,25.17 104.95,29.03 107.24,29.03 111.44,33.23 111.44,45.86 112.65,47.07 123.67,47.07 124.16,47.55 140.77,47.55 143.76,50.55 146.2,50.55 J32.12
SPI1_CSN1_M0: length 106.6
  TOP w0.152: J32.16 146.24,45.5 144.23,45.5 143.46,46.28 125.12,46.28 124.49,45.64 113.28,45.64 112.65,45.01 112.65,32.31 109.88,29.54 109.88,26.39 108.64,25.15 103.38,25.15 102.29,24.05 70.49,24.05 67.52,21.09 CN4.77
SPI1_MISO_M0: length 103.3
  TOP w0.152: CN4.75 67.12,21.45 70.05,24.38 101.83,24.38 104.65,27.2 108.64,27.2 109.25,27.81 109.25,29.57 112.32,32.64 112.32,45.34 113.06,46.08 124.16,46.08 124.74,46.66 144.6,46.66 J32.15
SPI1_MOSI_M0: length 104.7
  TOP w0.152: CN4.73 66.72,21.74 69.7,24.71 101.32,24.71 104.32,27.71 108.25,27.71 108.76,28.22 108.76,29.84 111.95,33.03 111.95,45.63 112.9,46.58 123.95,46.58 124.46,47.09 142.75,47.09 J32.13
SPK_CTRL: length 102.8
  TOP w0.152: R102.1 v1(23.83,54.87) ; CN3.72 89.92,49.74 91.03,50.85 91.03,51.3 v1(91.52,51.79) ; R225.1 v1(29.67,54.87)
  ART03 w0.152: v1(91.52,51.79) 89.2,54.1 89.2,55.24 88.22,56.23 88.22,57.72 88.98,58.47 88.98,63.33 86.77,65.54 86.77,68.4 85.55,69.62 54.71,69.62 54.28,69.19 54.28,67.59 53.04,66.34 48.36,66.34 46.48,68.22 42.65,68.22 42.44,68.02 40.89,68.02 40.31,67.44 40.31,62 39.7,61.39 39.7,58.17 38.89,57.35 38.89,56.33 v1(38.44,55.88)
  BOTTOM w0.152: v1(38.44,55.88) 37.44,55.88 35.94,54.38 30.16,54.38 v1(29.67,54.87) 25.52,54.87 25.04,55.35 24.31,55.35 v1(23.83,54.87)
SPK_LN: length 18.7
  TOP w0.254: v1(26.44,72.67) 27.15,71.96 C205.1 26.92,71.7 L18.2
  BOTTOM w0.254: J9.1 37.86,75.56 37.03,74.73 31.34,74.73 30.94,74.32 26.97,74.32 26.44,73.79 v1(26.44,72.67)
SPK_LP: length 25.6
  TOP w0.254: v1(23.57,72.69) 23.57,72.67 C90.1 23.11,71.7 L19.2
  BOTTOM w0.254: J9.2 39.86,74.08 38.89,73.1 34.21,73.1 33.43,73.89 31.6,73.89 30.94,73.23 27.76,73.23 27.36,72.82 27.36,72.19 26.95,71.78 24.49,71.78 v1(23.57,72.69)
SPK_RN: length 8.5
  TOP w0.254: v1(32.28,72.26) 32.72,72.26 C214.1 32.77,71.7 L20.2
  BOTTOM w0.254: J22.1 37.83,70.55 33.99,70.55 v1(32.28,72.26)
SPK_RP: length 14
  TOP w0.254: v1(29.49,72.26) 29.01,72.26 C213.1 28.96,71.7 L21.2
  BOTTOM w0.254: J22.2 38.63,71.75 34.26,71.75 32.92,73.1 31.88,73.1 31.04,72.26 v1(29.49,72.26)
SUB1: length 12.4
  TOP w0.109: v1(27.15,82.12) 27.05,82.22 J10.A8
  BOTTOM w0.109: v1(27.15,82.12) 27.41,82.37 arc(27.48,82.48) 27.5,82.6 D23.2 27.5,83.52 arc(27.43,83.7) 27.25,83.77 25.95,83.77 arc(25.79,83.74) 25.66,83.65 25.62,83.61 arc(25.53,83.48) 25.5,83.32 25.5,82.75 arc(25.46,82.52) 25.32,82.32 24.97,81.97 arc(24.77,81.83) 24.54,81.79 23.97,81.79 arc(23.81,81.76) 23.68,81.67 23.49,81.47 arc(23.4,81.34) 23.37,81.18 23.37,80.53 arc(23.39,80.41) 23.46,80.31 R123.1 23.44,79.69 arc(23.38,79.61) 23.36,79.51 23.36,79.49 arc(23.38,79.4) 23.44,79.32 R119.1 23.44,78.68 arc(23.38,78.59) 23.36,78.49 23.36,78.47 arc(23.38,78.36) 23.44,78.28 C105.1
SUB2: length 13.5
  TOP w0.109: v1(28.73,85.42) 28.8,85.34 J10.B8
  BOTTOM w0.109: C106.1 23.03,78.27 arc(23.09,78.36) 23.11,78.47 23.11,78.49 arc(23.09,78.6) 23.03,78.69 R122.1 23.04,79.31 arc(23.09,79.39) 23.11,79.49 23.11,79.51 arc(23.09,79.61) 23.04,79.7 R124.1 23.02,80.31 arc(23.09,80.41) 23.12,80.53 23.12,81.18 arc(23.17,81.44) 23.31,81.65 23.5,81.84 arc(23.72,81.99) 23.97,82.04 24.54,82.04 arc(24.68,82.06) 24.79,82.14 25.15,82.5 arc(25.23,82.61) 25.25,82.75 25.25,83.32 arc(25.3,83.57) 25.45,83.79 25.48,83.82 arc(25.7,83.97) 25.95,84.02 28.19,84.02 arc(28.31,84.04) 28.4,84.11 28.42,84.12 arc(28.48,84.22) 28.51,84.33 D24.2 28.51,85.05 arc(28.53,85.19) 28.61,85.3 v1(28.73,85.42)
SYS_LED: length 113.3
  TOP w0.152: CN3.70 89.52,49.85 90.52,50.85 v1(90.52,51.79) ; LED2.1 v1(142.33,1.56)
  ART03 w0.152: v1(90.52,51.79) 90.52,51.03 92.25,49.3 93.95,49.3 97.05,52.4 107.82,52.4 111.81,48.41 126.21,48.41 v1(128.03,50.23)
  BOTTOM w0.152: v1(142.33,1.56) 142.33,7 143.56,8.23 146.53,8.23 146.84,8.53 146.84,18.34 143.18,22 143.18,24.77 142.47,25.48 138.4,25.48 137.41,26.47 132.08,26.47 131.27,27.28 131.27,31.47 127.2,35.53 127.2,40.64 128.03,41.47 v1(128.03,50.23)
TYPEC_CC1: length 27.2
  TOP w0.152: v1(28.5,82.11) 28.55,82.17 J10.A5
  ART03 w0.152: v1(35.88,65.66) 36.32,66.1 36.32,68.61 35.74,69.19 35.74,78.89 35.17,79.46 35.17,80.37 34.64,80.9 34.2,80.9 v1(33.56,81.54)
  BOTTOM w0.152: v1(35.88,65.66) C96.1 36.31,66.84 U11.10 ; v1(33.56,81.54) 33.34,81.76 30.89,81.76 29.91,82.73 D21.2 28.76,82.73 28.5,82.48 v1(28.5,82.11)
TYPEC_CC2: length 36.9
  TOP w0.152: v1(27.43,85.37) 27.31,85.25 J10.B5
  ART03 w0.152: v1(42.16,68.5) 41.48,69.19 37.54,69.19 36.88,69.85 36.88,79.96 35.3,81.54 v1(34.56,81.54)
  BOTTOM w0.152: v1(27.43,85.37) 27.89,85.37 28.06,85.54 D22.2 28.75,86.13 29.26,85.62 30.25,85.62 30.71,86.08 33.38,86.08 33.88,85.57 33.88,82.45 34.56,81.77 v1(34.56,81.54) ; C95.1 41.92,68.26 v1(42.16,68.5) 41.68,68.99 40,68.99 39.69,68.68 U11.14
TYPEC_DM: length 18.6
  TOP w0.109: R108.1 27.66,78.2 arc(27.78,78.37) 27.82,78.57 27.82,78.95 arc(27.78,79.15) 27.66,79.32 27.51,79.48 arc(27.41,79.62) 27.37,79.8 D20.2 27.63,80.01 arc(27.69,80.02) 27.73,80.05 27.75,80.07 arc(27.78,80.12) 27.79,80.17 27.79,80.51 arc(27.78,80.59) 27.73,80.67 27.71,80.68 arc(27.64,80.73) 27.55,80.75 v1(27.37,80.75) 27.53,80.91 arc(27.64,81.07) 27.68,81.26 27.68,82.21 arc(27.67,82.28) 27.62,82.34 27.61,82.36 arc(27.57,82.42) 27.55,82.49 J10.A7 ; v1(27.97,87.33) 27.76,87.54 arc(27.69,87.59) 27.6,87.6 27.48,87.6 27.35,87.48 arc(27.19,87.1) 27.35,86.72 27.91,86.16 arc(28.12,85.85) 28.19,85.49 28.19,85.25 arc(28.2,85.18) 28.24,85.12 28.26,85.11 arc(28.3,85.04) 28.31,84.97 J10.B7
  ART03 w0.089: v1(27.97,87.33) 28.18,87.55 arc(28.28,87.62) 28.4,87.64 28.48,87.64 arc(28.54,87.63) 28.6,87.59 28.61,87.57 arc(28.65,87.52) 28.66,87.46 28.66,87.37 arc(28.64,87.25) 28.57,87.14 28.16,86.74 arc(28.03,86.53) 27.98,86.29 27.98,84.92 arc(27.96,84.82) 27.9,84.74 27.84,84.67 arc(27.74,84.53) 27.71,84.36 27.71,81.08 arc(27.68,80.96) 27.61,80.85 27.55,80.79 arc(27.5,80.76) 27.45,80.75 v1(27.37,80.75)
TYPEC_DP: length 19.1
  TOP w0.109: J10.B6 27.81,84.97 arc(27.83,85.04) 27.87,85.11 27.88,85.12 arc(27.93,85.18) 27.94,85.25 27.94,85.49 arc(27.89,85.76) 27.74,85.98 27.17,86.54 arc(26.95,87.1) 27.17,87.65 27.38,87.85 27.54,87.85 arc(27.67,87.88) 27.79,87.95 v1(27.97,88.13) ; J10.A6 28.05,82.49 arc(28.04,82.42) 28,82.36 27.98,82.34 arc(27.94,82.28) 27.93,82.21 27.93,81.26 arc(27.97,81.07) 28.07,80.91 v1(28.24,80.75) 28.17,80.75 arc(28.08,80.71) 28.04,80.62 28.04,80.23 arc(28.11,80.07) 28.26,80.01 D19.2 28.51,79.8 arc(28.47,79.62) 28.37,79.48 28.22,79.32 arc(28.1,79.15) 28.06,78.95 28.06,78.57 arc(28.1,78.37) 28.22,78.2 R107.1
  ART03 w0.089: v1(27.97,88.13) 28.15,87.95 arc(28.28,87.86) 28.44,87.83 28.48,87.83 arc(28.62,87.8) 28.73,87.72 28.75,87.71 arc(28.83,87.59) 28.85,87.46 28.85,87.37 arc(28.82,87.17) 28.7,87.01 28.3,86.6 arc(28.2,86.46) 28.17,86.29 28.17,84.92 arc(28.13,84.75) 28.04,84.6 27.97,84.54 arc(27.92,84.46) 27.9,84.36 27.9,81.26 arc(27.93,81.1) 28.02,80.96 v1(28.24,80.75)
TYPEC_DPTX_AUX_PUPDCTL1: length 95.9
  TOP w0.152: CN3.28 81.12,50.26 81.39,50.53 81.39,51.33 v1(80.9,51.81)
  ART03 w0.152: v1(19.94,73.66) 20.17,73.43 20.17,58.95 21.67,57.46 v1(21.67,56.72)
  BOTTOM w0.152: v1(21.67,56.72) 22.28,56.11 25.53,56.11 25.83,55.8 34.81,55.8 37.5,58.5 40.87,58.5 45.57,53.8 52.37,53.8 53.98,55.4 71.71,55.4 73.56,53.54 80.31,53.54 80.9,52.95 v1(80.9,51.81) ; R119.2 25.1,78.66 25.1,76.1 24.59,75.59 24.59,75.18 23.65,74.24 20.52,74.24 v1(19.94,73.66)
TYPEC_DPTX_AUX_PUPDCTL2: length 93.8
  TOP w0.152: CN3.26 80.72,49.51 80.82,49.6 80.82,50.72 v1(80.9,50.81)
  ART03 w0.152: v1(20.67,56.72) 19.15,58.23 19.15,77.39 v1(20.75,78.99)
  BOTTOM w0.152: v1(80.9,50.81) 80.42,51.3 80.42,52.81 80.06,53.16 73.36,53.16 72.14,54.38 65.15,54.38 64.57,54.97 55.17,54.97 53.59,53.39 45.49,53.39 40.79,58.09 37.62,58.09 34.92,55.4 25.6,55.4 25.27,55.73 21.66,55.73 v1(20.67,56.72) ; R122.2 v1(20.75,78.99)
TYPEC_SSRXN1: length 14.5
  TOP w0.109: R113.1 32.35,78.52 arc(32.27,78.63) 32.24,78.77 32.24,78.86 arc(32.26,78.93) 32.3,78.99 32.31,79 arc(32.35,79.07) 32.37,79.14 U16.5 U16.6 32.37,80.88 arc(32.35,80.95) 32.31,81.02 32.3,81.03 arc(32.26,81.09) 32.24,81.16 32.24,81.21 arc(32.26,81.31) 32.32,81.39 33.36,82.43 arc(33.7,82.95) 33.83,83.57 33.83,85.38 arc(33.74,85.84) 33.47,86.24 33.33,86.38 arc(33.1,86.53) 32.84,86.58 31.19,86.58 arc(30.95,86.53) 30.73,86.39 30.1,85.76 arc(29.97,85.57) 29.93,85.34 29.93,85.25 arc(29.92,85.18) 29.87,85.12 29.86,85.11 arc(29.82,85.04) 29.8,84.97 J10.B10
TYPEC_SSRXN2: length 5.7
  TOP w0.109: R117.1 25.49,78.52 arc(25.41,78.63) 25.39,78.77 25.39,78.86 arc(25.4,78.93) 25.44,78.99 25.46,79 arc(25.5,79.07) 25.51,79.14 U14.5 U14.6 25.51,80.88 arc(25.5,80.95) 25.46,81.02 25.44,81.03 arc(25.4,81.09) 25.39,81.16 25.39,81.23 arc(25.41,81.34) 25.47,81.43 25.81,81.77 arc(25.9,81.91) 25.94,82.08 25.94,82.28 26.06,82.41 J10.A10
TYPEC_SSRXP1: length 13.5
  TOP w0.109: R112.1 31.94,78.04 arc(31.98,78.09) 31.99,78.16 31.99,78.86 arc(31.98,78.93) 31.94,78.99 31.92,79 arc(31.88,79.07) 31.87,79.14 U16.4 U16.7 31.87,80.88 arc(31.88,80.95) 31.92,81.02 31.94,81.03 arc(31.98,81.09) 31.99,81.16 31.99,81.21 arc(32.03,81.4) 32.14,81.56 33.18,82.6 arc(33.48,83.05) 33.58,83.57 33.58,85.38 arc(33.51,85.75) 33.3,86.06 33.15,86.21 arc(33.01,86.3) 32.84,86.33 31.19,86.33 arc(31.04,86.3) 30.91,86.22 30.28,85.58 arc(30.2,85.47) 30.18,85.34 30.18,85.25 arc(30.19,85.18) 30.23,85.12 30.25,85.11 arc(30.29,85.04) 30.3,84.97 J10.B11
TYPEC_SSRXP2: length 5.5
  TOP w0.109: R114.1 25.09,78.04 arc(25.12,78.09) 25.14,78.16 25.14,78.86 arc(25.12,78.93) 25.08,78.99 25.07,79 arc(25.03,79.07) 25.01,79.14 U14.4 U14.7 25.01,80.88 arc(25.03,80.95) 25.07,81.02 25.08,81.03 arc(25.12,81.09) 25.14,81.16 25.14,81.23 arc(25.18,81.43) 25.29,81.6 25.63,81.94 arc(25.67,82.01) 25.69,82.08 25.69,82.28 25.56,82.41 J10.A11
TYPEC_SSTXN1: length 6
  TOP w0.109: J10.A3 29.56,82.41 29.69,82.28 29.69,81.97 29.89,81.77 arc(30.07,81.65) 30.28,81.61 30.38,81.61 arc(30.46,81.58) 30.49,81.5 30.49,81.16 arc(30.48,81.09) 30.44,81.03 30.42,81.02 arc(30.38,80.95) 30.37,80.88 U16.10 U16.1 30.37,79.14 arc(30.38,79.07) 30.42,79 30.44,78.99 arc(30.48,78.93) 30.49,78.86 30.49,78.77 arc(30.47,78.63) 30.39,78.52 C100.1
TYPEC_SSTXN2: length 14.9
  TOP w0.109: C102.1 23.53,78.52 arc(23.61,78.63) 23.64,78.77 23.64,78.86 arc(23.62,78.93) 23.58,78.99 23.57,79 arc(23.53,79.07) 23.51,79.14 U14.1 U14.10 23.51,80.88 arc(23.53,80.95) 23.57,81.02 23.58,81.03 arc(23.62,81.09) 23.64,81.16 23.64,81.25 arc(23.61,81.39) 23.54,81.5 22.1,82.93 arc(21.96,83.14) 21.91,83.39 21.91,85.44 arc(21.96,85.69) 22.1,85.9 22.57,86.38 arc(22.75,86.5) 22.96,86.54 25,86.54 arc(25.3,86.48) 25.55,86.31 25.95,85.9 arc(26.12,85.66) 26.18,85.36 26.18,85.25 arc(26.19,85.18) 26.23,85.12 26.25,85.11 arc(26.29,85.04) 26.3,84.97 J10.B3
TYPEC_SSTXP1: length 5.8
  TOP w0.109: J10.A2 30.06,82.41 29.94,82.28 29.94,82.08 30.06,81.95 arc(30.16,81.88) 30.28,81.86 30.38,81.86 arc(30.64,81.76) 30.74,81.5 30.74,81.16 arc(30.76,81.09) 30.8,81.03 30.81,81.02 arc(30.85,80.95) 30.87,80.88 U16.9 U16.2 30.87,79.14 arc(30.85,79.07) 30.81,79 30.8,78.99 arc(30.76,78.93) 30.74,78.86 30.74,78.16 arc(30.76,78.09) 30.79,78.04 C99.1
TYPEC_SSTXP2: length 13.9
  TOP w0.109: J10.B2 25.8,84.97 arc(25.82,85.04) 25.86,85.11 25.87,85.12 arc(25.92,85.18) 25.93,85.25 25.93,85.36 arc(25.89,85.56) 25.78,85.73 25.37,86.14 arc(25.2,86.25) 25,86.29 22.96,86.29 arc(22.85,86.27) 22.75,86.2 22.28,85.73 arc(22.19,85.6) 22.16,85.44 22.16,83.39 arc(22.19,83.24) 22.28,83.11 23.71,81.67 arc(23.84,81.48) 23.89,81.25 23.89,81.16 arc(23.9,81.09) 23.94,81.03 23.96,81.02 arc(24,80.95) 24.01,80.88 U14.9 U14.2 24.01,79.14 arc(24,79.07) 23.96,79 23.94,78.99 arc(23.9,78.93) 23.89,78.86 23.89,78.16 arc(23.9,78.09) 23.94,78.04 C101.1
TYPEC_VBUS_EN: length 71.1
  TOP w0.152: v1(39.3,42.23) 40.03,41.5 58.04,41.5 58.75,42.21 59.59,42.21 59.92,42.55 59.92,44.38 60.32,44.78 CN2.41
  ART03 w0.152: v1(39.3,42.23) 37.85,43.68 37.85,52.83 38.3,53.29 38.3,55.12 37.64,55.78 37.64,57.33 38.91,58.6 38.91,63.07 38.23,63.75 38.23,67.49 36.35,69.37 36.35,79.43 v1(35.65,80.12)
  BOTTOM w0.152: R118.1 31.59,80.62 35.16,80.62 v1(35.65,80.12)
U8_RX: length 17.6
  ART03 w0.152: J25.3 112.48,4.57 117.96,4.57 119.1,3.43 126.86,3.43 J27.5
U8_TX: length 15
  ART03 w0.152: J27.6 126.85,3 114.33,3 J25.2
U10_RX: length 20.1
  ART03 w0.152: J28.5 119.11,5.23 112.45,5.23 111.91,4.7 101.66,4.7 J26.3
U10_TX: length 17.9
  ART03 w0.152: J28.6 104.44,1.94 J26.2
UART0_RX: length 2
  TOP w0.152: U29.2 3.3,67.44 R187.2
UART0_RX_M0_DEBUG: length 144.1
  TOP w0.152: v1(4.38,7.9) 2.11,7.9 1.27,8.74 1.27,64.62 1.88,65.23 6.76,65.23 7.47,65.94 7.47,66.55 7.22,66.79 U29.4 ; CN4.66 v1(65.12,11.18)
  BOTTOM w0.152: v1(65.12,11.18) 65.12,15.6 61.42,19.3 45.52,19.3 44.35,18.14 40.13,18.14 39.19,17.2 26.52,17.2 25.58,18.14 18.11,18.14 16.92,16.94 16.92,13.41 14.91,11.4 14.91,9.73 14.02,8.84 5.32,8.84 v1(4.38,7.9)
UART0_TX: length 1.8
  TOP w0.152: U28.4 2.76,79.78 R186.2
UART0_TX_M0_DEBUG: length 153.7
  TOP w0.152: CN4.64 64.72,12.77 v1(64.62,12.87) ; v1(5.38,7.9) 4.85,8.43 2.31,8.43 1.63,9.12 1.63,64.46 2.03,64.86 7.05,64.86 7.83,65.64 7.83,69.33 6.81,70.36 6.81,74.6 7.31,75.11 7.31,78.78 6.96,79.13 U28.2
  BOTTOM w0.152: v1(5.38,7.9) 5.89,8.41 14.3,8.41 15.37,9.47 15.37,11.2 17.45,13.28 17.45,16.54 18.62,17.7 25.22,17.7 26.19,16.74 39.45,16.74 40.41,17.7 44.53,17.7 45.72,18.9 61.11,18.9 64.62,15.39 v1(64.62,12.87)
UART3_RX_M1: length 59.4
  TOP w0.152: v1(88.22,13.02) 88.32,12.92 CN5.64 ; v1(39.56,21.97) 39.24,21.66 U36.1
  BOTTOM w0.152: v1(39.56,21.97) 40.84,21.97 42.34,23.47 50.22,23.47 51.1,22.58 63.75,22.58 66.4,19.94 73.15,19.94 74.24,21.02 80.04,21.02 81.48,19.58 81.48,17.04 82.73,15.8 84.12,15.8 85.57,14.35 87.4,14.35 88.22,13.53 v1(88.22,13.02)
UART3_TX_M1: length 72
  TOP w0.152: CN5.66 v1(88.72,11.18) ; U36.4 35.43,19.05 35.71,18.77 39.4,18.77 40.08,19.46 40.08,22.15 39.78,22.45 39.07,22.45 v1(38.56,22.97)
  BOTTOM w0.152: v1(38.56,22.97) 39.07,22.45 40.74,22.45 42.16,23.88 50.44,23.88 51.33,22.99 64.03,22.99 66.45,20.57 72.77,20.57 74.22,22.02 80.01,22.02 81.99,20.04 81.99,17.27 82.91,16.36 84.15,16.36 85.75,14.76 87.76,14.76 88.72,13.79 v1(88.72,11.18)
UART5_RX_M0: length 76.1
  TOP w0.152: v1(89.72,11.18) 89.52,11.38 CN5.70 ; U37.1 32.51,18.59 32.82,18.29 39.57,18.29 40.51,19.23 40.51,22.33 39.87,22.97 v1(39.56,22.97)
  BOTTOM w0.152: v1(89.72,11.18) 89.72,14.19 88.29,15.62 86.06,15.62 83.49,18.19 83.49,20.27 80.34,23.42 73.99,23.42 72.29,21.72 66.8,21.72 64.69,23.83 51.82,23.83 50.93,24.71 41.3,24.71 v1(39.56,22.97)
UART5_TX_M0: length 76.6
  TOP w0.152: v1(89.22,13.02) 89.12,12.92 CN5.68 ; v1(40.56,22.97) 40.92,22.61 40.92,19.02 39.85,17.96 29.24,17.96 28.7,18.49 U37.4
  BOTTOM w0.152: v1(89.22,13.02) 89.22,14 88.06,15.16 85.95,15.16 82.98,18.14 82.98,19.96 79.93,23.01 74.3,23.01 72.49,21.21 66.52,21.21 64.31,23.42 51.51,23.42 50.62,24.31 41.89,24.31 v1(40.56,22.97)
UART8_RX: length 6.5
  BOTTOM w0.152: J27.3 130.45,7.35 130.08,7.71 D38.2 127.98,8.39 R203.2
UART8_RX_M2: length 54
  TOP w0.152: CN5.52 85.92,11.53 85.78,11.38 85.78,10.64 86.28,10.13 94.13,10.13 95.1,11.1 95.1,15.57 97.46,17.93 103.81,17.93 106.16,15.58 v1(106.16,13.12)
  BOTTOM w0.152: v1(106.16,13.12) 106.65,12.64 114.98,12.64 116.44,11.18 121.59,11.18 122.07,10.69 124.13,10.69 124.59,10.24 126.41,10.24 R203.1
UART8_TX: length 7.9
  BOTTOM w0.152: R204.2 130.77,8.39 D37.2 131.52,7.64 131.52,3.01 J27.4
UART8_TX_M2: length 56.5
  TOP w0.152: v1(107.16,13.12) 106.63,13.65 106.63,15.77 104.04,18.36 97.28,18.36 94.67,15.75 94.67,11.35 93.83,10.52 86.46,10.52 86.16,10.82 86.16,11.3 86.32,11.47 CN5.54
  BOTTOM w0.152: R204.1 130.05,10.06 129.41,10.69 124.89,10.69 124.46,11.13 122.35,11.13 121.83,11.65 117.59,11.65 116.12,13.12 v1(107.16,13.12)
