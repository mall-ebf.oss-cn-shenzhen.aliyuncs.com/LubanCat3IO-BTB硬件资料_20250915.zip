# Allegro board EBF410588V1R0_PCB_20251110.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_TX_D2N_PORT: length 21.8
  TOP w0.084: J33.3 98.59,80.48 arc(98.56,80.62) 98.48,80.74 98.41,80.81 arc(98.27,80.91) 98.1,80.94 98,80.94 arc(97.91,80.92) 97.84,80.88 97.69,80.72 arc(97.54,80.5) 97.49,80.23 97.49,78.89 arc(97.35,78.19) 96.95,77.6 94.2,74.84 arc(94.04,74.6) 93.98,74.32 93.98,68.65 arc(93.9,68.23) 93.66,67.88 93.1,67.32 arc(92.98,67.24) 92.84,67.21 92.48,67.21 arc(92.41,67.2) 92.36,67.16 91.91,66.71 arc(91.87,66.65) 91.86,66.58 91.86,66.34 arc(91.86,66.31) 91.88,66.28 91.96,66.2 arc(92.03,66.1) 92.05,65.97 D54.2 91.87,65.6 91.87,64.92 arc(91.88,64.86) 91.92,64.81 R229.1 91.85,64.16 arc(91.81,64.09) 91.79,64.01 91.79,63.99 arc(91.81,63.91) 91.85,63.84 C217.2
HDMI_TX_D2P: length 81.9
  TOP w0.084: CN2.69 65.92,45.48 arc(65.91,45.42) 65.88,45.37 65.87,45.36 arc(65.83,45.31) 65.82,45.25 65.82,44.28 arc(65.83,44.22) 65.87,44.17 v1(65.92,44.11) ; v1(91.22,59.43) 91.37,59.43 arc(91.41,59.44) 91.43,59.46 91.44,59.46 arc(91.55,59.63) 91.59,59.84 91.59,62.05 arc(91.59,62.08) 91.57,62.11 C216.1
  BOTTOM w0.084: v1(91.22,59.43) 91.35,59.56 arc(91.44,59.69) 91.47,59.84 91.47,59.87 arc(91.5,60.06) 91.61,60.22 91.63,60.23 arc(91.78,60.34) 91.97,60.38 92.29,60.38 arc(92.75,60.28) 93.14,60.02 93.54,59.62 arc(93.61,59.58) 93.68,59.56 96.72,59.56 arc(97.29,59.68) 97.77,60 97.88,60.11 arc(98.42,60.47) 99.06,60.6 102.18,60.6 arc(102.83,60.33) 103.09,59.69 103.09,59.37 arc(103.21,58.8) 103.53,58.32 103.67,58.18 arc(104.03,57.64) 104.16,56.99 104.16,56.6 arc(104.27,56.03) 104.59,55.55 105.09,55.06 arc(105.46,54.51) 105.58,53.87 105.58,45.9 arc(105.46,45.26) 105.09,44.71 98.46,38.09 arc(97.92,37.72) 97.28,37.6 76.63,37.6 arc(75.99,37.72) 75.45,38.09 75.26,38.28 arc(74.78,38.6) 74.21,38.71 68.18,38.71 arc(67.75,38.8) 67.38,39.05 66.25,40.17 arc(66.14,40.35) 66.1,40.55 66.1,41.87 arc(66.09,41.92) 66.06,41.96 65.59,42.43 arc(65.48,42.6) 65.44,42.8 65.44,42.96 65.43,42.97 65.43,43.12 arc(65.46,43.25) 65.53,43.35 65.8,43.63 arc(65.89,43.76) 65.92,43.92 v1(65.92,44.11)
HDMI_TX_D2P_PORT: length 21.8
  TOP w0.084: C216.2 91.53,63.83 arc(91.58,63.91) 91.59,63.99 91.59,64.01 arc(91.58,64.09) 91.53,64.17 R230.1 91.47,64.81 arc(91.62,65.03) 91.67,65.28 91.67,65.44 arc(91.64,65.57) 91.57,65.68 D53.2 91.46,65.97 arc(91.49,66.1) 91.55,66.2 91.63,66.28 arc(91.65,66.31) 91.66,66.34 91.66,66.58 arc(91.69,66.73) 91.77,66.85 92.22,67.3 arc(92.34,67.38) 92.48,67.41 92.84,67.41 arc(92.9,67.42) 92.96,67.46 93.52,68.02 arc(93.71,68.31) 93.78,68.65 93.78,74.32 arc(93.85,74.68) 94.06,74.98 96.81,77.74 arc(97.16,78.26) 97.29,78.89 97.29,80.23 arc(97.36,80.57) 97.55,80.86 97.7,81.02 arc(97.84,81.11) 98,81.14 98.05,81.14 arc(98.25,81.18) 98.41,81.29 J33.1
HDMI_TX_D3N: length 74.5
  TOP w0.084: v1(101.26,59.43) 101.38,59.43 arc(101.46,59.45) 101.53,59.49 101.54,59.5 arc(101.59,59.57) 101.6,59.65 101.6,60.1 arc(101.54,60.25) 101.39,60.31 101.22,60.31 arc(100.93,60.43) 100.81,60.72 100.81,60.73 arc(100.93,61.01) 101.21,61.13 101.39,61.13 arc(101.54,61.19) 101.6,61.34 101.6,61.94 arc(101.57,62.1) 101.48,62.23 C223.1 ; CN2.71 66.32,45.48 arc(66.33,45.42) 66.37,45.37 66.38,45.36 arc(66.41,45.31) 66.42,45.25 66.42,44.26 arc(66.48,43.99) 66.63,43.75 66.8,43.59 arc(66.89,43.45) 66.92,43.3 v1(66.92,43.11)
  BOTTOM w0.084: v1(66.92,43.11) 66.8,43.11 arc(66.71,43.08) 66.67,42.99 66.67,42.84 arc(66.7,42.73) 66.76,42.63 67.03,42.36 arc(67.11,42.25) 67.13,42.12 67.13,42.05 arc(67.15,42) 67.21,41.98 arc(67.26,41.95) 67.28,41.9 67.28,41.72 arc(67.26,41.66) 67.21,41.64 arc(67.15,41.62) 67.13,41.56 67.13,41.05 arc(67.16,40.91) 67.24,40.78 67.32,40.71 arc(67.37,40.69) 67.43,40.71 67.43,40.71 arc(67.49,40.73) 67.54,40.71 67.67,40.59 arc(67.69,40.53) 67.67,40.47 arc(67.64,40.42) 67.67,40.36 67.81,40.21 arc(68.02,40.07) 68.27,40.03 75.51,40.03 arc(76.15,39.9) 76.7,39.53 77.14,39.09 arc(77.62,38.77) 78.19,38.65 96.63,38.65 arc(97.2,38.77) 97.67,39.09 103.96,45.37 arc(104.28,45.85) 104.39,46.42 104.39,53.01 arc(104.28,53.57) 103.96,54.05 103.9,54.11 arc(103.42,54.43) 102.85,54.55 101.74,54.55 arc(101.45,54.67) 101.32,54.97 101.32,55.08 arc(101.47,55.44) 101.83,55.59 102.03,55.59 arc(102.24,55.8) 102.03,56.01 100.46,56.01 arc(100.19,56.12) 100.08,56.39 100.08,56.53 arc(100.23,56.88) 100.58,57.03 102.84,57.03 arc(103.05,57.24) 102.84,57.45 101.73,57.45 arc(101.44,57.57) 101.32,57.86 101.32,58.24 arc(101.37,58.5) 101.52,58.72 101.64,58.84 arc(101.71,58.94) 101.73,59.06 101.73,59.14 arc(101.71,59.25) 101.65,59.34 101.64,59.35 arc(101.55,59.41) 101.44,59.43 v1(101.26,59.43)
HDMI_TX_D3N_PORT: length 29.6
  TOP w0.084: J33.12 99.95,75.48 arc(100.08,75.56) 100.24,75.59 100.5,75.59 arc(100.55,75.57) 100.57,75.52 arc(100.6,75.46) 100.65,75.44 100.83,75.44 arc(100.89,75.46) 100.91,75.52 arc(100.93,75.57) 100.99,75.59 101.17,75.59 arc(101.22,75.57) 101.24,75.52 arc(101.27,75.46) 101.32,75.44 101.5,75.44 arc(101.56,75.46) 101.58,75.52 arc(101.6,75.57) 101.66,75.59 104.05,75.59 arc(104.2,75.56) 104.33,75.48 104.44,75.36 104.44,75.15 arc(104.38,75) 104.24,74.94 103.76,74.94 arc(103.35,74.53) 103.76,74.13 104.24,74.13 arc(104.44,73.92) 104.24,73.71 103.76,73.71 arc(103.35,73.3) 103.76,72.89 104.24,72.89 arc(104.44,72.68) 104.24,72.47 103.76,72.47 arc(103.35,72.06) 103.76,71.66 104.14,71.66 arc(104.36,71.57) 104.44,71.35 104.44,71.24 arc(104.38,71.09) 104.24,71.03 103.46,71.03 arc(103.05,70.62) 103.46,70.21 104.24,70.21 arc(104.44,70) 104.24,69.79 103.46,69.79 arc(103.05,69.39) 103.46,68.98 104.04,68.98 arc(104.33,68.86) 104.44,68.58 104.44,68.13 arc(104.42,67.98) 104.33,67.86 104.2,67.73 arc(104.08,67.64) 103.93,67.61 102.23,67.61 arc(102,67.57) 101.8,67.44 101.74,67.38 arc(101.61,67.18) 101.56,66.95 101.56,66.43 arc(101.54,66.31) 101.47,66.21 101.46,66.2 arc(101.39,66.1) 101.37,65.97 D52.2 101.48,65.68 arc(101.55,65.57) 101.57,65.44 101.57,65.05 arc(101.54,64.89) 101.46,64.76 R227.1 101.56,64.17 arc(101.61,64.09) 101.63,64.01 101.63,63.99 arc(101.61,63.91) 101.56,63.83 C223.2
HDMI_TX_D3P: length 74.4
  TOP w0.084: C222.1 101.92,62.18 arc(101.83,62.04) 101.8,61.89 101.8,61.34 arc(101.68,61.05) 101.39,60.93 101.21,60.93 arc(101.07,60.87) 101.01,60.73 101.01,60.72 arc(101.07,60.57) 101.22,60.51 101.39,60.51 arc(101.68,60.39) 101.8,60.1 101.8,59.94 arc(101.83,59.79) 101.92,59.66 v1(102.15,59.43) ; CN2.73 66.72,45.48 arc(66.71,45.42) 66.68,45.37 66.67,45.36 arc(66.63,45.31) 66.62,45.25 66.62,44.27 arc(66.67,44.16) 66.78,44.11 v1(66.92,44.11)
  BOTTOM w0.084: v1(102.15,59.43) 102.03,59.31 arc(101.95,59.2) 101.93,59.07 101.93,59.06 arc(101.89,58.87) 101.78,58.7 101.66,58.58 arc(101.56,58.43) 101.52,58.24 101.52,57.86 arc(101.58,57.71) 101.73,57.65 102.84,57.65 arc(103.25,57.24) 102.84,56.83 100.58,56.83 arc(100.37,56.74) 100.28,56.53 100.28,56.39 arc(100.33,56.26) 100.46,56.2 102.03,56.2 arc(102.44,55.8) 102.03,55.39 101.83,55.39 arc(101.61,55.3) 101.52,55.08 101.52,54.97 arc(101.59,54.81) 101.74,54.75 102.85,54.75 arc(103.5,54.62) 104.04,54.25 104.1,54.19 arc(104.46,53.65) 104.59,53.01 104.59,46.42 arc(104.46,45.78) 104.1,45.23 97.82,38.95 arc(97.27,38.58) 96.63,38.46 78.19,38.46 arc(77.55,38.58) 77,38.95 76.56,39.39 arc(76.08,39.71) 75.51,39.83 68.27,39.83 arc(67.95,39.89) 67.67,40.07 67.1,40.64 arc(66.98,40.83) 66.93,41.05 66.93,42.12 arc(66.92,42.18) 66.89,42.22 66.62,42.49 arc(66.51,42.65) 66.48,42.84 66.48,42.99 66.47,42.99 arc(66.41,43.15) 66.47,43.31 66.8,43.64 arc(66.89,43.77) 66.92,43.93 v1(66.92,44.11)
HDMI_TX_D3P_PORT: length 29.6
  TOP w0.084: J33.10 99.95,75.91 arc(100.08,75.82) 100.24,75.79 104.05,75.79 arc(104.28,75.75) 104.47,75.62 104.64,75.44 104.64,75.15 arc(104.52,74.86) 104.24,74.74 103.76,74.74 arc(103.55,74.53) 103.76,74.32 104.24,74.32 arc(104.64,73.92) 104.24,73.51 103.76,73.51 arc(103.55,73.3) 103.76,73.09 104.24,73.09 arc(104.64,72.68) 104.24,72.27 103.76,72.27 arc(103.55,72.06) 103.76,71.86 104.14,71.86 arc(104.5,71.71) 104.64,71.35 104.64,71.24 arc(104.52,70.95) 104.24,70.83 103.46,70.83 arc(103.25,70.62) 103.46,70.41 104.24,70.41 arc(104.64,70) 104.24,69.59 103.46,69.59 arc(103.25,69.39) 103.46,69.18 104.04,69.18 arc(104.47,69) 104.64,68.58 104.64,68.13 arc(104.6,67.91) 104.47,67.72 104.34,67.59 arc(104.15,67.46) 103.93,67.42 102.23,67.42 arc(102.08,67.39) 101.94,67.3 101.88,67.24 arc(101.79,67.1) 101.76,66.95 101.76,66.43 arc(101.79,66.31) 101.86,66.21 101.87,66.2 arc(101.94,66.1) 101.96,65.97 D51.2 101.86,65.69 arc(101.8,65.59) 101.77,65.47 101.77,65.15 arc(101.8,65) 101.89,64.87 R228.1 101.89,64.16 arc(101.84,64.09) 101.82,64.01 101.82,63.99 arc(101.84,63.91) 101.89,63.84 C222.2
HDMI_TX_EARC+: length 11.4
  TOP w0.084: C224.2 99.09,63.72 arc(99,63.85) 98.97,64 98.97,65.46 arc(98.99,65.58) 99.06,65.68 D44.2 99.17,65.97 arc(99.14,66.1) 99.07,66.2 99.06,66.21 arc(98.99,66.31) 98.97,66.43 98.97,70.01 arc(99,70.15) 99.08,70.27 99.99,71.19 arc(100.15,71.42) 100.2,71.7 100.2,72.92 arc(100.12,73.31) 99.9,73.65 J33.14
HDMI_TX_EARC-: length 10.7
  TOP w0.084: R149.2 C225.2 98.54,63.73 arc(98.71,63.99) 98.77,64.29 98.77,65.46 arc(98.75,65.58) 98.68,65.68 D31.2 98.57,65.97 arc(98.6,66.1) 98.67,66.2 98.68,66.21 arc(98.75,66.31) 98.77,66.43 98.77,66.97 arc(98.75,67.02) 98.7,67.04 arc(98.65,67.06) 98.63,67.11 98.63,67.3 arc(98.65,67.35) 98.7,67.37 arc(98.75,67.39) 98.77,67.44 98.77,67.64 arc(98.75,67.69) 98.7,67.71 arc(98.65,67.73) 98.63,67.78 98.63,67.97 arc(98.65,68.02) 98.7,68.04 arc(98.75,68.06) 98.77,68.11 98.77,68.31 arc(98.75,68.36) 98.7,68.38 arc(98.65,68.4) 98.63,68.45 98.63,68.64 arc(98.65,68.69) 98.7,68.71 arc(98.75,68.73) 98.77,68.78 98.77,68.98 arc(98.75,69.03) 98.7,69.05 arc(98.65,69.07) 98.63,69.12 98.63,69.31 arc(98.65,69.36) 98.7,69.38 arc(98.75,69.4) 98.77,69.46 98.77,70.01 arc(98.81,70.23) 98.94,70.41 99.33,70.81 arc(99.38,70.93) 99.33,71.05 99.11,71.27 arc(98.92,71.35) 98.73,71.27 98.59,71.13 J33.19
HDMI_TX_HPDIN_M0: length 25.7
  TOP w0.152: v1(86.52,50.79) 86.52,50.56 86.32,50.36 CN3.54 ; R141.2 101.76,54.86 101.21,55.42 101.21,57.85 100.98,58.08 Q8.3 98.01,58.08 v1(97.54,57.61)
  BOTTOM w0.152: v1(86.52,50.79) 86.57,50.79 87.02,51.23 87.02,52.1 87.33,52.4 94.11,52.4 94.89,53.19 94.89,55.52 96.98,57.61 v1(97.54,57.61)
HDMI_TX_ON_H: length 14.2
  TOP w0.152: R164.1 v1(94.34,54.86) ; v1(86.52,51.79) 86.01,51.27 86.01,50.59 85.92,50.5 CN3.52
  BOTTOM w0.152: v1(86.52,51.79) 86.52,52.28 87.07,52.83 93.75,52.83 94.34,53.42 v1(94.34,54.86)
HDMI_TX_SBDN: length 94.6
  TOP w0.084: CN2.75 67.12,45.48 arc(67.13,45.42) 67.17,45.37 67.18,45.36 arc(67.21,45.31) 67.22,45.25 67.22,45.07 arc(67.26,44.88) 67.36,44.72 67.37,44.72 arc(67.44,44.62) 67.46,44.5 67.46,44.07 arc(67.49,43.93) 67.57,43.81 67.81,43.57 arc(67.89,43.44) 67.92,43.29 v1(67.92,43.11) ; v1(98.34,59.43) 98.42,59.43 arc(98.49,59.44) 98.55,59.48 98.61,59.54 arc(98.68,59.65) 98.71,59.78 98.71,61.92 arc(98.68,62.07) 98.59,62.2 C225.1
  BOTTOM w0.084: v1(98.34,59.43) 98.54,59.22 arc(98.65,59.07) 98.68,58.88 98.68,58.88 arc(98.8,58.59) 99.09,58.47 99.62,58.47 arc(99.83,58.26) 99.62,58.05 99.09,58.05 arc(98.8,57.93) 98.68,57.64 98.68,55.46 arc(98.8,55.17) 99.09,55.05 99.8,55.05 arc(100,54.84) 99.8,54.63 99.19,54.63 arc(98.83,54.48) 98.68,54.13 98.68,54.01 arc(98.8,53.72) 99.09,53.61 102.82,53.61 arc(103.03,53.4) 102.82,53.19 99.09,53.19 arc(98.68,52.78) 99.09,52.37 103.25,52.37 arc(103.46,52.16) 103.25,51.95 99.09,51.95 arc(98.8,51.83) 98.68,51.54 98.68,51.45 arc(98.72,51.27) 98.82,51.11 98.84,51.1 arc(98.99,50.99) 99.18,50.96 103.22,50.96 arc(103.37,50.9) 103.43,50.75 103.43,46.43 arc(103.4,46.29) 103.32,46.17 100.46,43.31 arc(100.31,43.25) 100.16,43.31 99.88,43.6 arc(99.3,43.6) 99.3,43.02 99.59,42.73 arc(99.65,42.59) 99.59,42.44 99.59,42.44 arc(99.44,42.38) 99.29,42.44 99,42.72 arc(98.43,42.72) 98.43,42.15 98.71,41.86 arc(98.77,41.71) 98.71,41.56 arc(98.56,41.5) 98.42,41.56 98.13,41.85 arc(97.55,41.85) 97.55,41.27 97.84,40.99 arc(97.9,40.84) 97.84,40.69 97.84,40.69 arc(97.69,40.63) 97.54,40.69 97.26,40.98 arc(96.68,40.98) 96.68,40.4 96.91,40.17 arc(97,39.96) 96.91,39.76 96.9,39.75 arc(96.68,39.6) 96.41,39.55 78.05,39.55 arc(77.91,39.58) 77.8,39.65 76.64,40.81 arc(76.33,41.02) 75.96,41.09 75.64,41.09 arc(75.58,41.12) 75.56,41.17 arc(75.54,41.23) 75.48,41.25 75.3,41.25 arc(75.25,41.23) 75.22,41.17 arc(75.2,41.12) 75.15,41.09 74.97,41.09 arc(74.91,41.12) 74.89,41.17 arc(74.87,41.23) 74.81,41.25 74.63,41.25 arc(74.58,41.23) 74.55,41.17 arc(74.53,41.12) 74.48,41.09 74.3,41.09 arc(74.24,41.12) 74.22,41.17 arc(74.2,41.23) 74.14,41.25 73.96,41.25 arc(73.91,41.23) 73.88,41.17 arc(73.86,41.12) 73.8,41.09 73.63,41.09 arc(73.57,41.12) 73.55,41.17 arc(73.53,41.23) 73.47,41.25 73.29,41.25 arc(73.24,41.23) 73.21,41.17 arc(73.19,41.12) 73.13,41.09 72.96,41.09 arc(72.9,41.12) 72.88,41.17 arc(72.85,41.23) 72.8,41.25 72.62,41.25 arc(72.57,41.23) 72.54,41.17 arc(72.52,41.12) 72.46,41.09 72.29,41.09 arc(72.23,41.12) 72.21,41.17 arc(72.18,41.23) 72.13,41.25 71.95,41.25 arc(71.89,41.23) 71.87,41.17 arc(71.85,41.12) 71.79,41.09 71.62,41.09 arc(71.56,41.12) 71.54,41.17 arc(71.51,41.23) 71.46,41.25 71.28,41.25 arc(71.22,41.23) 71.2,41.17 arc(71.18,41.12) 71.12,41.09 70.94,41.09 arc(70.89,41.12) 70.87,41.17 arc(70.84,41.23) 70.79,41.25 70.61,41.25 arc(70.55,41.23) 70.53,41.17 arc(70.51,41.12) 70.45,41.09 70.27,41.09 arc(70.22,41.12) 70.2,41.17 arc(70.17,41.23) 70.12,41.25 69.94,41.25 arc(69.88,41.23) 69.86,41.17 arc(69.84,41.12) 69.78,41.09 69.6,41.09 arc(69.55,41.12) 69.52,41.17 arc(69.5,41.23) 69.45,41.25 69.27,41.25 arc(69.21,41.23) 69.19,41.17 arc(69.17,41.12) 69.11,41.09 68.93,41.09 arc(68.88,41.12) 68.85,41.17 arc(68.83,41.23) 68.78,41.25 68.6,41.25 arc(68.54,41.23) 68.52,41.17 arc(68.5,41.12) 68.44,41.09 68.23,41.09 arc(68.06,41.16) 68,41.33 68,41.57 arc(68.02,41.62) 68.07,41.64 arc(68.13,41.67) 68.15,41.72 68.15,41.9 arc(68.13,41.96) 68.07,41.98 arc(68.02,42) 68,42.05 68,42.13 arc(67.97,42.26) 67.9,42.36 67.75,42.51 arc(67.67,42.63) 67.64,42.78 67.64,42.96 arc(67.68,43.07) 67.79,43.11 v1(67.92,43.11)
HDMI_TX_SBDP: length 93
  TOP w0.084: C224.1 99.02,62.2 arc(98.94,62.07) 98.91,61.92 98.91,59.92 arc(98.94,59.76) 99.02,59.63 v1(99.22,59.43) ; v1(67.92,44.11) 67.8,44.11 arc(67.71,44.15) 67.67,44.25 67.67,44.54 arc(67.64,44.69) 67.55,44.82 67.51,44.86 arc(67.44,44.96) 67.42,45.07 67.42,45.25 arc(67.43,45.31) 67.47,45.36 67.48,45.37 arc(67.51,45.42) 67.52,45.48 CN2.77
  BOTTOM w0.084: v1(67.92,44.11) 67.92,43.93 arc(67.89,43.78) 67.81,43.65 67.44,43.28 arc(67.37,43.12) 67.44,42.97 67.44,42.96 67.44,42.78 arc(67.49,42.56) 67.61,42.37 67.76,42.22 arc(67.79,42.18) 67.8,42.13 67.8,41.33 arc(67.92,41.02) 68.23,40.89 75.96,40.89 arc(76.25,40.84) 76.5,40.67 77.66,39.51 arc(77.84,39.39) 78.05,39.35 96.41,39.35 arc(96.75,39.42) 97.04,39.61 97.05,39.62 arc(97.19,39.96) 97.05,40.31 96.82,40.54 arc(96.82,40.84) 97.12,40.84 97.4,40.55 arc(97.69,40.43) 97.98,40.55 97.98,40.55 arc(98.1,40.84) 97.98,41.13 97.69,41.41 arc(97.69,41.71) 97.99,41.71 98.28,41.42 arc(98.56,41.3) 98.85,41.42 98.85,41.42 arc(98.97,41.71) 98.85,42 98.57,42.29 arc(98.57,42.58) 98.86,42.58 99.15,42.3 arc(99.44,42.18) 99.73,42.3 99.73,42.3 arc(99.85,42.59) 99.73,42.87 99.44,43.16 arc(99.44,43.46) 99.74,43.46 100.02,43.17 arc(100.31,43.05) 100.6,43.17 103.46,46.03 arc(103.58,46.22) 103.63,46.43 103.63,50.75 arc(103.51,51.04) 103.22,51.16 99.18,51.16 arc(99.07,51.18) 98.98,51.24 98.96,51.25 arc(98.9,51.34) 98.88,51.45 98.88,51.54 arc(98.94,51.69) 99.09,51.75 103.25,51.75 arc(103.66,52.16) 103.25,52.57 99.09,52.57 arc(98.88,52.78) 99.09,52.99 102.82,52.99 arc(103.23,53.4) 102.82,53.8 99.09,53.8 arc(98.94,53.86) 98.88,54.01 98.88,54.13 arc(98.97,54.34) 99.19,54.43 99.8,54.43 arc(100.2,54.84) 99.8,55.25 99.09,55.25 arc(98.94,55.31) 98.88,55.46 98.88,57.64 arc(98.94,57.79) 99.09,57.85 99.62,57.85 arc(100.03,58.26) 99.62,58.67 99.09,58.67 arc(98.94,58.73) 98.88,58.88 98.88,58.89 arc(98.92,59.07) 99.02,59.23 v1(99.22,59.43)
HDMI_TX_SCL: length 17.8
  TOP w0.152: CN3.50 v1(85.52,50.79)
  BOTTOM w0.152: Q6.2 88.71,63.43 R139.2 88.11,62.83 88.11,58.83 86.09,56.81 86.09,54.44 85.04,53.39 85.04,51.27 v1(85.52,50.79)
HDMI_TX_SCL_PORT: length 16.6
  BOTTOM w0.152: J33.15 98.18,73.79 D45.2 96.16,73.66 95.8,73.3 94.74,73.3 94.08,72.64 94.08,70.41 92.48,68.81 90.5,68.81 89.66,67.97 Q6.3 91.14,66.84 R140.2
HDMI_TX_SDA: length 33
  TOP w0.152: v1(85.52,51.79) 85.01,51.27 85.01,50.6 85.12,50.49 CN3.48
  BOTTOM w0.152: v1(85.52,51.79) 85.52,53.16 86.56,54.2 86.56,56.57 88.57,58.57 88.57,61.24 90.03,62.7 94.48,62.7 94.95,63.17 99.06,63.17 100.1,64.21 101.07,64.21 Q7.2 102.35,64.12 104.5,64.12 R146.2
HDMI_TX_SDA_PORT: length 10.4
  BOTTOM w0.152: J33.16 100.37,72.8 102.89,70.29 D46.2 102.89,67.84 102.62,67.56 Q7.3 101.97,66.84 101.4,66.27 100.69,66.27 R147.2
HP_BUTTON_DET: length 76.4
  TOP w0.152: v1(91.52,50.79) 91.43,50.79 90.32,49.68 CN3.74
  ART03 w0.203: v1(43.18,74.3) 42.34,73.46 42.34,70.97 42.85,70.46 43.76,70.46 44.37,71.07 48.39,71.07 48.95,70.51 49.89,70.51 50.22,70.18 87,70.18 87.88,69.29 87.88,65.15 89.33,63.7 89.33,58.78 90.35,57.76 90.35,54.64 92.05,52.93 92.05,51.31 v1(91.52,50.79)
  BOTTOM w0.203: R83.2 43.95,74.3 R86.1 ; R86.1 C77.1 ; R86.1 43.19,74.29 v1(43.18,74.3)
HP_PLUG_IN_DET: length 61.9
  TOP w0.152: CN3.76 90.72,49.57 91.26,50.11 91.57,50.11 92.01,50.55 92.01,51.27 92.53,51.79 v1(92.56,51.79)
  TOP w0.203: R88.2 52.08,70.37 v1(52.43,70.71)
  ART03 w0.203: v1(52.43,70.71) 88.01,70.71 89.15,69.57 89.15,64.85 89.71,64.29 89.71,59.41 91,58.13 91,55.84 92.56,54.28 v1(92.56,51.79)
I2C2_SCL_M0: length 165.9
  TOP w0.152: J13.9 140.45,16.55 137.83,19.17 v1(137.83,19.56) ; CN2.15 55.12,44.31 v1(54.92,44.11) 54.91,44.11 54.44,43.65 54.44,42.93 54.14,42.62 41.22,42.62 37.77,46.08 34.04,46.08 33.12,46.99 30.48,46.99 v1(29.87,46.38) ; v1(28.87,50.92) 29.39,50.39 30.38,50.39 30.9,50.92 35.22,50.92 37.11,52.81 37.11,62.61 38.69,64.2 v1(38.69,64.44)
  ART03 w0.152: v1(28.87,50.92) 29.49,50.3 29.49,46.76 v1(29.87,46.38) ; v1(97.5,31.08) 97.5,30.91 97.01,30.42 97.01,25.26 98.07,24.21 123.19,24.21 123.77,23.62 129.64,23.62 131.9,21.36 136.02,21.36 v1(137.83,19.56)
  BOTTOM w0.152: R239.2 54.43,42.38 54.43,43.64 54.91,44.11 v1(54.92,44.11) 55.41,43.63 55.41,40.78 58.54,37.65 61.47,37.65 66.36,32.77 95.81,32.77 v1(97.5,31.08) ; U11.6 v1(38.69,64.44)
I2C2_SDA_M0: length 159.5
  TOP w0.152: CN2.17 55.52,44.4 55.44,44.31 55.44,43.63 v1(54.92,43.11) 54.92,42.81 54.36,42.24 40.92,42.24 37.62,45.54 33.78,45.54 32.94,46.38 v1(30.87,46.38) ; v1(137.74,20.52) 138.83,19.44 138.83,18.96 140.74,17.05 J13.10 ; v1(37.64,64.44) 37.64,63.7 36.77,62.83 36.77,53.02 35.15,51.41 30.63,51.41 v1(30.14,50.92)
  ART03 w0.152: v1(30.87,46.38) 30.87,47.01 30.14,47.74 v1(30.14,50.92) ; v1(97.5,30.03) 97.5,29.91 97.97,29.43 97.97,25.27 98.55,24.69 129.57,24.69 131.88,22.38 133.65,22.38 134.09,21.95 136.88,21.95 137.74,21.08 v1(137.74,20.52)
  BOTTOM w0.152: v1(37.64,64.44) 37.98,64.44 38.19,64.65 U11.7 ; v1(97.5,30.03) 97.5,30.08 95.17,32.41 66.01,32.41 61.18,37.24 58.12,37.24 R240.2 54.92,41.85 v1(54.92,43.11)
I2C3_SCL_M0: length 166.1
  TOP w0.152: v1(30.14,51.92) 35.08,51.92 36.42,53.26 36.42,63.04 37.16,63.78 37.16,64.69 37.54,65.07 42.49,65.07 43.31,65.89 44.64,65.89 v1(45.11,65.41) 45.48,65.79 46.41,65.79 46.78,65.41 U9.28 ; J14.6 v1(7.67,14.85) ; CN5.38 83.12,12.92 v1(83.22,13.02)
  ART03 w0.152: v1(45.11,65.41) 46.15,64.37 46.15,62.05 48.39,59.82 48.39,58.75 49.38,57.76 49.38,27.13 46.41,24.16 46.41,22.14 v1(44.31,20.05)
  BOTTOM w0.152: v1(30.14,51.92) 30.87,52.65 U5.6 ; v1(7.67,14.85) 8.15,15.33 10.05,15.33 10.41,15.7 10.41,16.18 10.69,16.46 12.06,16.46 12.4,16.79 13.28,16.79 13.67,17.17 13.67,19.33 14.58,20.24 44.12,20.24 v1(44.31,20.05) 44.38,20.12 62.03,20.12 65.66,16.48 73.03,16.48 74.09,15.42 75.61,15.42 R162.2 79.15,14.86 80.71,13.3 80.71,12.84 81.1,12.45 82.64,12.45 v1(83.22,13.02)
I2C3_SDA_M0: length 171.5
  TOP w0.152: v1(8.67,14.85) 8.17,14.35 J14.5 ; CN5.36 v1(82.72,11.18) ; v1(30.14,52.92) 30.61,52.45 34.96,52.45 36.09,53.58 36.09,63.35 36.78,64.03 36.78,64.85 37.47,65.53 42.19,65.53 43.64,66.98 44.54,66.98 v1(45.11,66.41) 46.36,66.41 47.23,65.54 U9.27
  ART03 w0.152: v1(45.11,66.41) 46.74,64.79 46.74,62.41 49.38,59.77 49.38,58.72 50.42,57.68 50.42,53.8 49.83,53.21 49.83,26.74 46.91,23.83 46.91,21.65 v1(44.31,19.05)
  BOTTOM w0.152: v1(30.14,52.92) 30.52,53.3 U5.5 ; v1(8.67,14.85) 9.04,14.48 11.05,14.48 11.38,14.81 11.38,15.27 11.71,15.6 13,15.6 14.17,16.76 14.17,19.02 14.96,19.81 43.55,19.81 v1(44.31,19.05) 44.97,19.71 61.75,19.71 65.41,16.05 72.72,16.05 73.66,15.11 73.66,13.72 74.09,13.28 75.61,13.28 R160.2 79.3,13.84 79.74,13.4 79.74,12.72 80.54,11.91 81.99,11.91 v1(82.72,11.18)
I2C4_SCL_M2: length 108.6
  TOP w0.152: v1(13.4,24.78) 12.39,23.77 10.74,23.77 5.55,28.97 5.55,30.78 5.03,31.29 5.03,33.55 5.53,34.05 J15.6 ; v1(91.72,11.18) 91.52,11.38 CN5.80
  BOTTOM w0.152: v1(91.72,11.18) 91.72,11.2 92.2,11.68 92.72,11.68 R188.2 92.85,12.32 91.47,12.32 91.16,12.62 91.16,14.96 89.33,16.79 86.58,16.79 84.94,18.43 84.94,21.23 81.58,24.59 65.94,24.59 65.38,25.15 52.58,25.15 51.77,25.96 16,25.96 14.82,24.78 v1(13.4,24.78)
I2C4_SDA_M2: length 105.7
  TOP w0.152: J15.5 5.77,33.55 5.46,33.25 5.46,31.5 5.99,30.96 5.99,29.18 10.92,24.26 11.6,24.26 v1(12.13,24.78) ; CN5.78 91.12,12.81 91.34,13.02 v1(92.22,13.02)
  BOTTOM w0.152: R163.2 93.04,13.02 v1(92.22,13.02) 92.22,14.03 91.62,14.63 91.62,15.16 89.56,17.22 86.76,17.22 85.39,18.59 85.39,21.62 82.07,24.94 66.14,24.94 65.53,25.55 52.88,25.55 52.04,26.39 15.67,26.39 14.61,25.32 12.67,25.32 v1(12.13,24.78)
I2C5_SCL_M3: length 120.5
  TOP w0.152: CN5.79 91.52,15.35 92.21,16.03 92.21,17.68 92.51,17.99 93.21,17.99 v1(93.72,18.51)
  ART03 w0.152: v1(31.91,31.75) 32.41,31.25 32.41,23.12 v1(32.56,22.97)
  BOTTOM w0.152: v1(32.56,22.97) 32.03,23.5 24.94,23.5 24.13,22.68 22.99,22.68 22.2,23.47 12.09,23.47 9.97,21.35 J16.6 ; v1(31.91,31.75) 32.42,32.26 34.19,32.26 34.85,31.6 36.7,31.6 37.85,32.74 40.01,32.74 42.34,35.08 62.78,35.08 65.86,32 91.01,32 92.89,30.12 92.89,20.17 93.24,19.82 93.24,18.99 v1(93.72,18.51) 94.46,18.51 R190.2
I2C5_SDA_M3: length 122.7
  TOP w0.152: CN5.77 91.12,15.51 91.72,16.11 91.72,18.2 92.03,18.51 v1(92.72,18.51)
  ART03 w0.152: v1(33.56,22.97) 33.54,22.97 33.05,22.48 32.21,22.48 31.91,22.78 v1(31.91,30.75)
  BOTTOM w0.152: J16.5 9.91,21.85 11.94,23.88 22.37,23.88 23.16,23.09 23.96,23.09 24.85,23.98 32.55,23.98 v1(33.56,22.97) ; v1(31.91,30.75) 31.91,30.27 32.49,29.69 34.92,29.69 35.59,30.35 40.44,30.35 41.17,31.09 41.17,32.08 43.21,34.11 62.38,34.11 65.33,31.17 90.14,31.17 91.89,29.42 91.89,19.34 v1(92.72,18.51) 92.75,18.51 93.24,18.01 94.98,18.01 R189.2
I2C7_SCL_M1: length 221.5
  TOP w0.152: J32.5 143.13,57.63 143.13,50.72 140.41,48.01 123.9,48.01 123.44,47.55 112.45,47.55 110.92,46.02 110.92,33.38 v1(110.85,33.3) ; v1(13.4,22.23) 12.66,22.96 10.19,22.96 5.71,27.43 3.15,27.43 2.09,28.49 2.09,50.6 2.87,51.38 3.63,51.38 5.12,52.87 J18.6 ; v1(84.22,13.02) 83.92,12.72 CN5.42
  ART03 w0.152: v1(84.22,13.02) 84.22,13.33 84.89,14 89.15,14 91.67,16.51 91.67,33.5 94.69,36.53 107.62,36.53 v1(110.85,33.3)
  BOTTOM w0.152: v1(84.22,13.02) 84.22,13.26 83.54,13.94 81.58,13.94 78.46,17.07 R236.2 75.66,17.6 65.91,17.6 62.53,20.98 14.2,20.98 13.4,21.78 v1(13.4,22.23)
I2C7_SDA_M1: length 226
  TOP w0.152: v1(83.72,11.18) 83.52,11.38 CN5.40 ; v1(109.85,33.3) 110.51,33.97 110.51,46.35 112.09,47.93 123.06,47.93 123.55,48.41 139.93,48.41 142.6,51.08 142.6,59.64 J32.3 ; J18.5 5.25,52.37 3.81,50.93 3.05,50.93 2.54,50.42 2.54,28.75 3.4,27.89 5.94,27.89 10.46,23.37 13.03,23.37 13.89,22.5 13.89,21.92 13.4,21.42 v1(13.4,20.95)
  ART03 w0.152: v1(109.85,33.3) 109.85,33.66 107.47,36.04 94.82,36.04 92.1,33.32 92.1,16.33 89.33,13.56 85.08,13.56 84.74,13.22 84.74,12.19 v1(83.72,11.18)
  BOTTOM w0.152: v1(13.4,20.95) 13.78,20.57 62.26,20.57 65.86,16.97 73.69,16.97 74.17,16.48 75.66,16.48 R235.2 78.74,15.95 81.18,13.51 83.42,13.51 83.72,13.21 v1(83.72,11.18)
I2C8_SCL_M2: length 138.3
  TOP w0.152: v1(38.3,42.23) 38.3,43.36 37.11,44.55 33.12,44.55 32.23,45.44 28.6,45.44 27.86,44.7 23.31,44.7 21.13,46.89 17.92,46.89 v1(16.24,48.56) ; CN5.76 v1(90.72,11.18)
  ART03 w0.152: v1(34.56,22.97) 35.07,22.45 35.77,22.45 36.07,22.76 36.07,23.35 37.11,24.38 39.9,24.38 42.48,26.96 42.48,40.09 40.94,41.63 38.9,41.63 v1(38.3,42.23)
  BOTTOM w0.152: v1(34.56,22.97) 37.16,25.57 51.47,25.57 52.33,24.71 65.21,24.71 66.29,23.62 R238.2 70.19,24.21 81.15,24.21 84.4,20.95 84.4,18.39 86.39,16.4 88.98,16.4 90.72,14.66 v1(90.72,11.18) ; v1(16.24,48.56) 15.68,48.01 12.9,48.01 12.22,47.32 12.22,46.58 11.85,46.22 11.85,42.38 10.02,40.55 J17.6
I2C8_SDA_M2: length 131.8
  TOP w0.152: CN5.74 90.32,12.92 v1(90.22,13.02) ; v1(37.3,42.23) 37.3,42.99 36.73,43.56 32.21,43.56 31.62,44.15 23.11,44.15 20.9,46.35 17.45,46.35 v1(15.24,48.56)
  ART03 w0.152: v1(35.56,22.97) 35.56,23.49 36.91,24.84 39.67,24.84 42.03,27.19 42.03,39.81 40.72,41.12 38.41,41.12 v1(37.3,42.23)
  BOTTOM w0.152: v1(35.56,22.97) 37.68,25.1 51.18,25.1 52.04,24.23 65.05,24.23 66.93,22.35 71.88,22.35 72.64,23.11 R237.2 72.84,23.83 80.72,23.83 84,20.55 84,18.24 86.21,16.03 88.65,16.03 90.22,14.45 v1(90.22,13.02) ; J17.5 9.88,41.05 11.4,42.57 11.4,46.4 11.77,46.77 11.77,47.53 12.8,48.56 v1(15.24,48.56)
LCD_BL_PWM: length 136.7
  TOP w0.152: CN2.10 53.92,49.91 53.41,50.43 53.41,51.32 52.94,51.79 v1(52.92,51.79) ; v1(51.67,26.99) 52.18,27.51 52.18,28.19 52.56,28.57 54.18,28.57 56.47,30.87 95.16,30.87 95.5,30.54 v1(95.5,30.03) ; J13.13 141.89,18.55 v1(141.39,19.05)
  ART03 w0.152: v1(141.39,19.05) 139.92,17.58 137.41,17.58 136.04,18.95 131.75,18.95 129.67,21.03 123.77,21.03 122.94,20.19 110.06,20.19 108.99,19.13 98.22,19.13 95,22.35 95,29.4 95.5,29.91 v1(95.5,30.03) ; v1(52.92,51.79) 52.5,51.36 52.5,49.66 50.83,47.98 50.83,27.83 v1(51.67,26.99)
LCD_PWR_EN: length 86.2
  TOP w0.152: v1(60.92,44.11) 61.12,44.31 CN2.45
  ART03 w0.152: v1(97.5,34.54) 94.08,34.54 93.52,33.99 93.52,32.82 93.01,32.31 93.01,21.03 96.9,17.14 109.65,17.14 110.03,16.76 110.92,16.76 111.53,17.37 v1(111.53,18.28)
  BOTTOM w0.152: R153.1 v1(111.53,18.28) ; v1(97.5,34.54) 67.07,34.54 61.85,39.76 61.85,43.19 v1(60.92,44.11)
LCD_RST: length 131.6
  TOP w0.152: v1(94.5,29.08) 94.01,29.57 57.43,29.57 54.33,26.47 53.19,26.47 v1(52.67,26.99) ; v1(53.92,50.79) 53.92,50.42 54.32,50.02 CN2.12 ; v1(142.39,19.05) 142.39,19.24 142.7,19.55 J13.15
  ART03 w0.152: v1(142.39,19.05) 141.81,18.46 141.81,17.63 141.58,17.4 140.75,17.4 140.31,16.97 137.19,16.97 135.84,18.31 131.65,18.31 129.95,20.02 123.8,20.02 123.34,19.56 110.19,19.56 109.27,18.64 97.94,18.64 94.5,22.09 v1(94.5,29.08) ; v1(52.67,26.99) 52.18,27.47 52.18,28.85 51.87,29.16 51.87,47.42 53.92,49.48 v1(53.92,50.79)
LOUT1: length 6.8
  TOP w0.203: U9.12 48.58,59.96 v1(48.85,59.69)
  BOTTOM w0.203: v1(48.85,59.69) 48.51,60.03 48.51,60.71 49,61.19 49,62.89 C81.2
LOUT2: length 41.3
  TOP w0.203: v1(35.88,64.66) 35.88,64.48 35.03,63.63 35.03,54.66 34.1,53.74 28.06,53.74 C86.1 ; v1(51.13,61.29) 50.91,61.51 U9.15
  BOTTOM w0.203: v1(51.13,61.29) 50.29,61.29 50.01,61.01 50.01,60.3 50.37,59.94 50.37,59.28 49.89,58.8 45.57,58.8 43.23,61.14 43.23,62.33 42.75,62.81 41.56,62.81 40.72,63.65 36.89,63.65 v1(35.88,64.66)
MASKROM: length 18.4
  BOTTOM w0.152: SW1.2 144.42,81.58 142.93,80.09 142.93,75.23 141.13,73.44 D11.2 140.28,71.37 139.65,72.01 138.29,72.01 137.66,71.38 C25.1 137.58,71.37 137.05,71.9 135.78,71.9 R27.1
MIC1N: length 1.4
  TOP w0.203: C74.2 R85.2
MIC1P: length 1.4
  TOP w0.203: R81.2 C71.2
MIC2N: length 31.7
  TOP w0.203: C76.2 v1(52.42,68.95)
  ART03 w0.203: v1(52.42,68.95) 52.27,68.8 49.11,68.8 48.13,69.77 42.46,69.77 41.48,70.76 41.48,79.4 40.86,80.01 39.67,80.01 39.26,80.42 39.26,81.19 v1(39.61,81.53)
  BOTTOM w0.203: C89.2 40.63,82.8 R101.1 ; C89.2 39.27,83.15 39.27,85.64 P1.2 ; C89.2 39.29,82.48 39.29,81.85 v1(39.61,81.53)
MIC2P: length 36
  TOP w0.203: C75.2 50.6,69.52 52.85,69.52 v1(53.42,68.95)
  ART03 w0.203: v1(38.61,81.53) 38.91,81.24 38.91,80.27 39.52,79.65 40.72,79.65 41.12,79.25 41.12,70.61 42.34,69.39 47.96,69.39 48.9,68.44 52.63,68.44 53.14,68.95 v1(53.42,68.95)
  BOTTOM w0.203: C89.1 38.94,82.48 38.94,81.86 v1(38.61,81.53) ; C89.1 38.91,83.1 38.91,85.19 P1.1 ; C89.1 37.6,82.8 R99.2
MINIPCIE_3V3: length 31.1
  TOP w0.254: C174.1 v1(132.51,8.5)
  TOP w0.381: J20.52 136.19,20.53 135.89,20.83 C173.1 v1(136.59,21.47) ; v1(125.09,24.16) 125.76,23.5 125.76,21.97 125.26,21.47 C172.1 124.99,21.36 J20.24 ; v1(111.79,21.69) 112.3,21.69 C175.1 112.99,21.01 J20.2
  ART04 w0.254: v1(108.03,28.44) 108.03,27.78 108.58,27.23 110.82,27.23 112.75,25.3 119.84,25.3 120.32,24.82 120.32,23.67
  BOTTOM w0.254: v1(113.08,7.62) 113.16,7.7 R179.1 ; C164.2 R172.2 v1(108.03,28.44)
  vias: v1(119.71,21.66) v1(119.71,20.66) v1(120.71,21.66) v1(120.71,20.66) v1(121.71,21.66) v1(121.71,20.66) v1(133.51,8.5)
MINIPCIE_NWDISABLE: length 113.4
  TOP w0.152: v1(95.5,29.08) 94.98,29.6 94.98,30.23 94.68,30.53 56.9,30.53 54.36,27.99 v1(53.67,27.99) ; R182.2 121.79,22.47 121.19,21.88 121.19,19.36 120.68,18.85 120.68,16.84 119.52,15.69 113.14,15.69 112.06,16.76 108.92,16.76 108.37,17.31 v1(108.37,19.68) ; CN2.20 v1(55.92,50.79)
  ART03 w0.152: v1(108.37,19.68) 107.95,20.09 98.17,20.09 95.5,22.77 v1(95.5,29.08) ; v1(53.67,27.99) 53.67,29.49 53.44,29.72 53.44,45.87 54,46.43 54,47.02 55.92,48.94 v1(55.92,50.79)
MINIPCIE_PWR_EN: length 115.6
  TOP w0.152: CN2.22 56.32,50.5 56.41,50.59 56.41,51.3 v1(55.92,51.79)
  ART03 w0.152: v1(53.67,26.99) 53.18,27.47 53.18,29.21 52.91,29.49 52.91,46.05 53.42,46.56 53.42,47.32 55.41,49.31 55.41,51.27 55.92,51.78 v1(55.92,51.79) ; v1(92.72,14.51) 93.5,14.51 95.71,16.71 106.57,16.71 v1(107.16,16.12)
  BOTTOM w0.152: v1(92.72,14.51) 92.72,14.8 89.94,17.58 86.94,17.58 85.78,18.75 85.78,22.05 82.5,25.32 66.34,25.32 65.68,25.98 54.64,25.98 53.67,26.95 v1(53.67,26.99) ; v1(107.16,16.12) 104.55,18.73 104.55,29.06 105.26,29.77 112.8,29.77 113.16,29.41 R177.1
MIPI_DPHY_CSI0_RX_CLKN: length 99.9
  TOP w0.084: v1(9.83,17) 9.83,16.94 arc(9.76,16.77) 9.59,16.7 7.6,16.7 arc(7.51,16.72) 7.43,16.77 7.42,16.78 arc(7.35,16.83) 7.26,16.85 J14.10 ; v1(29.2,36.99) 29.16,36.95 29.16,36.85 arc(29.17,36.79) 29.21,36.73 29.23,36.71 arc(29.3,36.66) 29.38,36.64 30.87,36.64 arc(31.37,36.74) 31.79,37.03 31.92,37.15 arc(32.34,37.44) 32.84,37.54 32.96,37.54 arc(33.36,37.62) 33.7,37.84 33.77,37.91 arc(34.17,38.18) 34.65,38.27 72.23,38.27 arc(72.79,38.39) 73.27,38.71 77.59,43.02 arc(77.91,43.5) 78.02,44.07 78.02,45.25 arc(78.01,45.31) 77.98,45.36 77.97,45.37 arc(77.93,45.42) 77.92,45.48 CN3.11
  ART03 w0.076: v1(9.83,17) 9.67,16.85 arc(9.51,16.74) 9.32,16.7 arc(9.13,16.78) 9.05,16.97 9.05,17.17 arc(9.08,17.28) 9.13,17.36 9.45,17.68 arc(9.56,17.85) 9.6,18.05 9.6,20.92 arc(9.78,21.84) 10.31,22.63 11.5,23.82 arc(11.93,24.11) 12.43,24.21 13.39,24.21 arc(13.87,24.41) 14.07,24.89 14.07,28.61 arc(14.17,29.12) 14.46,29.55 16.94,32.02 arc(17.36,32.31) 17.87,32.41 21.92,32.41 arc(22.91,32.61) 23.75,33.17 24.76,34.17 arc(25.8,35.73) 26.16,37.57 26.16,38.38 arc(26.22,38.68) 26.39,38.93 26.6,39.14 arc(26.74,39.24) 26.91,39.27 27.66,39.27 arc(27.71,39.25) 27.74,39.19 arc(27.76,39.14) 27.81,39.12 28.04,39.12 arc(28.09,39.14) 28.12,39.19 arc(28.14,39.25) 28.19,39.27 28.4,39.27 arc(28.44,39.25) 28.46,39.2 arc(28.48,39.16) 28.52,39.14 28.7,39.14 arc(28.75,39.16) 28.76,39.2 arc(28.78,39.25) 28.83,39.27 29.01,39.27 arc(29.05,39.25) 29.07,39.2 arc(29.09,39.16) 29.13,39.14 29.31,39.14 arc(29.35,39.16) 29.37,39.2 arc(29.39,39.25) 29.44,39.27 29.66,39.27 arc(29.88,39.18) 29.97,38.96 29.97,38.54 arc(29.95,38.49) 29.91,38.47 arc(29.86,38.46) 29.84,38.41 29.84,38.23 arc(29.86,38.19) 29.91,38.17 arc(29.95,38.15) 29.97,38.11 29.97,37.93 arc(29.95,37.88) 29.91,37.87 arc(29.86,37.85) 29.84,37.8 29.84,37.62 arc(29.86,37.58) 29.91,37.56 arc(29.95,37.54) 29.97,37.5 29.97,37.32 arc(29.95,37.27) 29.91,37.26 arc(29.86,37.24) 29.84,37.19 29.84,37.01 arc(29.86,36.97) 29.91,36.95 arc(29.95,36.93) 29.97,36.89 29.97,36.74 arc(29.91,36.6) 29.78,36.54 29.49,36.54 arc(29.29,36.63) 29.2,36.83 v1(29.2,36.99)
MIPI_DPHY_CSI0_RX_CLKP: length 100
  TOP w0.084: J14.9 7.26,16.35 arc(7.35,16.37) 7.42,16.42 7.44,16.43 arc(7.51,16.48) 7.6,16.5 9.32,16.5 arc(9.51,16.46) 9.67,16.35 v1(9.83,16.2) ; CN3.13 78.32,45.48 arc(78.31,45.42) 78.28,45.37 78.27,45.36 arc(78.23,45.31) 78.22,45.25 78.22,44.07 arc(78.09,43.43) 77.73,42.88 73.41,38.57 arc(72.87,38.2) 72.23,38.07 34.65,38.07 arc(34.25,37.99) 33.91,37.77 33.84,37.7 arc(33.44,37.43) 32.96,37.34 32.84,37.34 arc(32.42,37.25) 32.06,37.01 31.93,36.89 arc(31.44,36.56) 30.87,36.44 29.78,36.44 arc(29.57,36.4) 29.38,36.28 v1(29.2,36.1)
  ART03 w0.076: v1(9.83,16.2) 9.67,16.35 arc(9.51,16.46) 9.32,16.5 arc(8.99,16.64) 8.85,16.97 8.85,17.17 arc(8.89,17.35) 8.99,17.51 9.31,17.82 arc(9.37,17.93) 9.4,18.05 9.4,18.34 9.4,20.92 arc(9.6,21.92) 10.16,22.77 11.36,23.96 arc(11.85,24.29) 12.43,24.41 13.39,24.41 arc(13.73,24.55) 13.87,24.89 13.87,28.61 arc(13.98,29.2) 14.31,29.69 16.79,32.17 arc(17.29,32.5) 17.87,32.61 21.92,32.61 arc(22.84,32.8) 23.61,33.31 24.61,34.32 arc(25.61,35.81) 25.96,37.57 25.96,38.38 arc(26.03,38.76) 26.24,39.07 26.46,39.29 arc(26.66,39.42) 26.91,39.47 29.66,39.47 arc(30.02,39.32) 30.18,38.96 30.18,36.74 arc(30.06,36.45) 29.78,36.34 29.6,36.34 arc(29.45,36.31) 29.33,36.22 v1(29.2,36.1)
MIPI_DPHY_CSI0_RX_D0N: length 106.5
  TOP w0.084: v1(10.85,18.33) 10.67,18.16 arc(10.54,18.07) 10.38,18.04 8.7,18.04 arc(8.48,17.99) 8.29,17.87 8.23,17.81 arc(8.11,17.73) 7.96,17.7 7.6,17.7 arc(7.51,17.72) 7.43,17.77 7.42,17.78 arc(7.35,17.83) 7.26,17.85 J14.12 ; v1(27.6,38.6) 27.83,38.37 arc(27.96,38.29) 28.11,38.26 28.37,38.26 arc(28.52,38.29) 28.64,38.37 29.53,39.26 arc(29.96,39.54) 30.46,39.64 58.53,39.64 arc(58.82,39.7) 59.07,39.87 59.14,39.94 arc(59.35,40.08) 59.59,40.13 60.3,40.13 arc(60.54,40.08) 60.74,39.94 60.82,39.87 arc(60.95,39.78) 61.1,39.75 71.68,39.75 arc(71.82,39.78) 71.94,39.86 76.09,44.01 arc(76.34,44.38) 76.42,44.82 76.42,45.25 arc(76.41,45.31) 76.38,45.36 76.37,45.37 arc(76.33,45.42) 76.32,45.48 CN3.3
  ART03 w0.076: v1(10.85,18.33) 10.85,18.23 arc(10.83,18.14) 10.78,18.07 10.72,18.01 arc(10.64,17.95) 10.54,17.93 10.42,17.93 10.36,17.99 arc(10.32,18.05) 10.31,18.11 10.31,20.81 arc(10.41,21.31) 10.7,21.74 11.2,22.24 arc(11.63,22.53) 12.14,22.63 14.5,22.63 arc(14.74,22.73) 14.83,22.96 14.83,23.29 arc(14.89,23.43) 15.02,23.48 16.09,23.48 arc(16.48,23.88) 16.09,24.27 15.1,24.27 arc(14.91,24.35) 14.83,24.54 14.83,24.66 arc(14.88,24.78) 15,24.83 16.12,24.83 arc(16.51,25.22) 16.12,25.61 15.02,25.61 arc(14.83,25.8) 15.02,25.99 16.12,25.99 arc(16.51,26.39) 16.12,26.78 15.02,26.78 arc(14.83,26.97) 15.02,27.16 16.12,27.16 arc(16.51,27.56) 16.12,27.95 15.03,27.95 arc(14.89,28.01) 14.83,28.15 14.83,28.17 arc(14.87,28.35) 14.97,28.5 17.66,31.19 arc(18.08,31.47) 18.59,31.57 21.62,31.57 arc(23.17,31.88) 24.49,32.76 25.62,33.89 arc(26.03,34.17) 26.52,34.26 27.16,34.26 arc(27.58,34.35) 27.94,34.59 28.13,34.78 arc(28.46,35.27) 28.57,35.85 28.57,35.88 arc(28.39,36.33) 27.94,36.52 27.34,36.52 arc(27.15,36.71) 27.34,36.9 28.18,36.9 arc(28.46,37.02) 28.57,37.29 28.57,37.79 arc(28.47,38.05) 28.2,38.16 27.74,38.16 arc(27.66,38.17) 27.59,38.22 27.56,38.25 arc(27.5,38.41) 27.56,38.56 v1(27.6,38.6)
MIPI_DPHY_CSI0_RX_D0P: length 106.4
  TOP w0.084: J14.11 7.26,17.35 arc(7.35,17.37) 7.42,17.42 7.44,17.43 arc(7.51,17.48) 7.6,17.5 7.96,17.5 arc(8.19,17.54) 8.37,17.67 8.43,17.73 arc(8.56,17.81) 8.7,17.84 10.28,17.84 arc(10.49,17.8) 10.67,17.68 10.85,17.5 v1(10.85,17.44) ; v1(27.6,37.71) 27.83,37.94 arc(27.96,38.03) 28.11,38.06 28.37,38.06 arc(28.59,38.1) 28.78,38.23 29.67,39.12 arc(30.03,39.36) 30.46,39.45 58.53,39.45 arc(58.9,39.52) 59.21,39.73 59.28,39.8 arc(59.42,39.9) 59.59,39.93 60.3,39.93 arc(60.46,39.9) 60.6,39.8 60.68,39.73 arc(60.87,39.6) 61.1,39.55 71.68,39.55 arc(71.89,39.6) 72.08,39.72 76.23,43.87 arc(76.52,44.3) 76.62,44.82 76.62,45.25 arc(76.63,45.31) 76.67,45.36 76.68,45.37 arc(76.71,45.42) 76.72,45.48 CN3.5
  ART03 w0.076: v1(10.85,17.44) 10.63,17.66 arc(10.55,17.71) 10.46,17.73 10.34,17.73 10.22,17.85 arc(10.14,17.97) 10.11,18.11 10.11,20.81 arc(10.23,21.39) 10.56,21.88 11.06,22.39 arc(11.55,22.72) 12.14,22.83 14.5,22.83 arc(14.59,22.87) 14.63,22.96 14.63,23.29 arc(14.75,23.57) 15.02,23.69 16.09,23.69 arc(16.28,23.88) 16.09,24.07 15.1,24.07 arc(14.77,24.2) 14.63,24.54 14.63,24.66 arc(14.74,24.92) 15,25.03 16.12,25.03 arc(16.31,25.22) 16.12,25.41 15.02,25.41 arc(14.63,25.8) 15.02,26.2 16.12,26.2 arc(16.31,26.39) 16.12,26.58 15.02,26.58 arc(14.63,26.97) 15.02,27.37 16.12,27.37 arc(16.31,27.56) 16.12,27.75 15.03,27.75 arc(14.75,27.86) 14.63,28.15 14.63,28.17 arc(14.68,28.43) 14.83,28.65 17.51,31.33 arc(18.01,31.66) 18.59,31.78 21.62,31.78 arc(23.09,32.07) 24.35,32.91 25.48,34.04 arc(25.95,34.36) 26.52,34.47 27.16,34.47 arc(27.5,34.54) 27.8,34.73 27.98,34.92 arc(28.27,35.35) 28.37,35.85 28.37,35.88 arc(28.24,36.19) 27.94,36.32 27.34,36.32 arc(26.95,36.71) 27.34,37.1 28.18,37.1 arc(28.32,37.16) 28.37,37.29 28.37,37.79 arc(28.32,37.91) 28.2,37.95 28,37.95 arc(27.85,37.92) 27.73,37.84 v1(27.6,37.71)
MIPI_DPHY_CSI0_RX_D1N: length 107.3
  TOP w0.084: v1(10.9,15.94) 10.9,15.87 10.8,15.78 arc(10.71,15.72) 10.6,15.7 7.6,15.7 arc(7.51,15.72) 7.43,15.77 7.42,15.78 arc(7.35,15.83) 7.26,15.85 J14.8 ; v1(30.94,38.33) 30.94,38.05 arc(30.99,37.93) 31.1,37.88 31.35,37.88 arc(31.41,37.89) 31.47,37.93 32.01,38.47 arc(32.55,38.83) 33.19,38.96 71.62,38.96 arc(72.19,39.07) 72.67,39.39 76.79,43.52 arc(77.11,44) 77.22,44.56 77.22,45.25 arc(77.21,45.31) 77.18,45.36 77.17,45.37 arc(77.13,45.42) 77.12,45.48 CN3.7
  ART03 w0.076: v1(30.94,38.33) 30.89,38.28 arc(30.84,38.16) 30.89,38.05 30.93,38.01 arc(31.08,37.9) 31.27,37.87 31.4,37.87 arc(31.59,37.95) 31.67,38.14 31.67,38.91 arc(31.66,38.96) 31.63,39 31.53,39.11 arc(31.48,39.13) 31.43,39.11 arc(31.38,39.09) 31.33,39.11 31.21,39.22 arc(31.19,39.27) 31.21,39.32 arc(31.23,39.37) 31.21,39.42 31.1,39.54 arc(31.05,39.56) 31,39.54 31,39.54 arc(30.95,39.52) 30.9,39.54 30.78,39.65 arc(30.76,39.7) 30.78,39.75 30.78,39.76 arc(30.8,39.81) 30.78,39.86 30.67,39.97 arc(30.62,39.99) 30.57,39.97 arc(30.51,39.95) 30.46,39.97 30.35,40.08 arc(30.33,40.14) 30.35,40.19 arc(30.37,40.24) 30.35,40.29 30.23,40.41 arc(30.17,40.45) 30.1,40.46 29.93,40.46 arc(29.89,40.44) 29.87,40.4 arc(29.85,40.35) 29.8,40.34 29.63,40.34 arc(29.58,40.35) 29.56,40.4 arc(29.54,40.44) 29.5,40.46 29.32,40.46 arc(29.28,40.44) 29.26,40.4 arc(29.24,40.35) 29.2,40.34 29.02,40.34 arc(28.97,40.35) 28.95,40.4 arc(28.94,40.44) 28.89,40.46 28.71,40.46 arc(28.67,40.44) 28.65,40.4 arc(28.63,40.35) 28.59,40.34 28.41,40.34 arc(28.36,40.35) 28.34,40.4 arc(28.33,40.44) 28.28,40.46 28.1,40.46 arc(28.06,40.44) 28.04,40.4 arc(28.02,40.35) 27.98,40.34 27.8,40.34 arc(27.75,40.35) 27.73,40.4 arc(27.72,40.44) 27.67,40.46 27.06,40.46 arc(26.58,40.37) 26.18,40.1 25.61,39.53 arc(25.32,39.1) 25.22,38.59 25.22,38.18 arc(24.76,35.87) 23.46,33.91 23.28,33.74 arc(22.77,33.39) 22.16,33.27 17.62,33.27 arc(17.12,33.17) 16.69,32.89 12.91,29.11 arc(12.79,28.93) 12.75,28.72 12.75,28.58 arc(12.63,28.29) 12.35,28.18 11.64,28.18 arc(11.45,27.99) 11.64,27.8 12.18,27.8 arc(12.58,27.63) 12.75,27.22 12.75,27.19 arc(12.58,26.78) 12.16,26.61 11.95,26.61 arc(11.76,26.42) 11.95,26.23 12.33,26.23 arc(12.7,26.07) 12.85,25.71 12.85,25.69 arc(12.7,25.32) 12.33,25.17 10.5,25.17 arc(10,25.07) 9.57,24.78 8.95,24.16 arc(8.66,23.73) 8.56,23.23 8.56,18.16 arc(8.52,17.94) 8.39,17.75 8.27,17.63 arc(8.15,17.45) 8.1,17.23 8.1,16.54 arc(8.17,16.18) 8.37,15.88 8.39,15.87 arc(8.68,15.67) 9.04,15.6 10.32,15.6 arc(10.54,15.65) 10.72,15.77 v1(10.9,15.94)
MIPI_DPHY_CSI0_RX_D1P: length 107.2
  TOP w0.084: v1(10.9,15.06) 10.57,15.38 arc(10.44,15.47) 10.28,15.5 7.6,15.5 arc(7.51,15.48) 7.44,15.43 7.42,15.42 arc(7.35,15.37) 7.26,15.35 J14.7 ; v1(30.94,37.44) 31.07,37.58 arc(31.19,37.65) 31.33,37.68 31.35,37.68 arc(31.49,37.71) 31.61,37.79 32.15,38.33 arc(32.63,38.65) 33.19,38.76 71.62,38.76 arc(72.26,38.89) 72.81,39.25 76.93,43.38 arc(77.29,43.92) 77.42,44.56 77.42,45.25 arc(77.43,45.31) 77.47,45.36 77.48,45.37 arc(77.51,45.42) 77.52,45.48 CN3.9
  ART03 w0.076: v1(30.94,37.44) 31.06,37.56 arc(31.18,37.64) 31.32,37.66 31.4,37.66 arc(31.74,37.8) 31.88,38.14 31.88,38.91 arc(31.85,39.04) 31.78,39.15 30.37,40.55 arc(30.25,40.64) 30.1,40.67 27.06,40.67 arc(26.5,40.55) 26.03,40.24 25.47,39.67 arc(25.14,39.18) 25.02,38.59 25.02,38.18 arc(24.58,35.95) 23.31,34.06 23.14,33.88 arc(22.69,33.58) 22.16,33.48 17.62,33.48 arc(17.04,33.36) 16.55,33.03 12.77,29.25 arc(12.6,29.01) 12.55,28.72 12.55,28.58 arc(12.49,28.44) 12.35,28.38 11.64,28.38 arc(11.25,27.99) 11.64,27.59 12.18,27.59 arc(12.44,27.49) 12.55,27.22 12.55,27.19 arc(12.44,26.92) 12.16,26.81 11.95,26.81 arc(11.56,26.42) 11.95,26.02 12.33,26.02 arc(12.56,25.93) 12.65,25.71 12.65,25.69 arc(12.56,25.47) 12.33,25.37 10.5,25.37 arc(9.92,25.26) 9.43,24.93 8.8,24.31 arc(8.47,23.81) 8.36,23.23 8.36,18.16 arc(8.33,18.02) 8.25,17.9 8.12,17.78 arc(7.96,17.53) 7.9,17.23 7.9,16.54 arc(7.98,16.11) 8.23,15.74 8.24,15.73 arc(8.61,15.48) 9.04,15.4 10.4,15.4 arc(10.54,15.37) 10.66,15.29 v1(10.9,15.06)
MIPI_DPHY_CSI0_RX_D2N: length 100
  TOP w0.084: J14.17 7.26,20.35 arc(7.35,20.33) 7.42,20.28 7.43,20.27 arc(7.51,20.22) 7.6,20.2 10.43,20.2 arc(10.59,20.23) 10.71,20.31 10.81,20.41 arc(10.83,20.44) 10.84,20.48 v1(10.84,20.53) ; v1(33.01,36.53) 33.19,36.35 arc(33.38,36.23) 33.59,36.19 33.69,36.19 arc(33.98,36.24) 34.22,36.41 34.94,37.12 arc(35.48,37.48) 36.12,37.61 72.81,37.61 arc(73.38,37.72) 73.86,38.05 78.39,42.58 arc(78.71,43.06) 78.82,43.62 78.82,45.25 arc(78.81,45.31) 78.78,45.36 78.77,45.37 arc(78.73,45.42) 78.72,45.48 CN3.15
  ART03 w0.076: v1(33.01,36.53) 33.01,36.34 arc(32.99,36.25) 32.94,36.17 32.93,36.16 arc(32.85,36.11) 32.76,36.09 32.47,36.09 arc(32.13,36.02) 31.84,35.83 31.74,35.73 arc(31.48,35.35) 31.39,34.89 31.39,33.51 arc(31.35,33.3) 31.23,33.12 31.22,33.11 arc(31.04,32.99) 30.83,32.94 30.12,32.94 arc(29.56,32.83) 29.08,32.51 27.71,31.14 arc(26.67,30.44) 25.44,30.2 19.04,30.2 arc(18.84,30.16) 18.67,30.05 18.06,29.44 arc(17.95,29.27) 17.91,29.07 17.91,20.78 arc(17.85,20.64) 17.72,20.59 17.03,20.59 arc(16.64,20.19) 17.03,19.8 17.72,19.8 arc(17.85,19.74) 17.91,19.61 17.91,19.5 arc(17.89,19.41) 17.84,19.34 17.82,19.32 arc(17.75,19.27) 17.66,19.25 16.22,19.25 arc(16.1,19.3) 16.05,19.42 16.05,19.78 arc(15.65,20.18) 15.26,19.78 15.26,19.44 arc(15.07,19.25) 14.88,19.44 14.88,19.69 arc(14.74,20.03) 14.39,20.18 14.28,20.18 arc(14,20.06) 13.89,19.78 13.89,19.04 arc(13.7,18.85) 13.51,19.04 13.51,19.69 arc(13.37,20.03) 13.02,20.18 12.91,20.18 arc(12.63,20.06) 12.52,19.78 12.52,19.37 arc(12.33,19.18) 12.14,19.37 12.14,19.69 arc(11.99,20.05) 11.62,20.2 11.39,20.2 arc(11.19,20.24) 11.01,20.36 v1(10.84,20.53)
MIPI_DPHY_CSI0_RX_D2P: length 100
  TOP w0.084: CN3.17 79.12,45.48 arc(79.11,45.42) 79.08,45.37 79.07,45.36 arc(79.03,45.31) 79.02,45.25 79.02,43.62 arc(78.89,42.98) 78.53,42.44 74,37.91 arc(73.46,37.54) 72.81,37.41 36.12,37.41 arc(35.56,37.3) 35.08,36.98 34.36,36.27 arc(34.05,36.06) 33.69,35.99 33.59,35.99 arc(33.38,35.94) 33.19,35.82 v1(33.01,35.64) ; v1(10.84,19.64) 10.6,19.88 arc(10.47,19.97) 10.31,20 7.6,20 arc(7.51,19.98) 7.43,19.93 7.42,19.92 arc(7.35,19.87) 7.26,19.85 J14.16
  ART03 w0.076: v1(33.01,35.64) 32.89,35.77 arc(32.76,35.85) 32.61,35.88 32.47,35.88 arc(32.2,35.83) 31.98,35.68 31.88,35.58 arc(31.67,35.27) 31.6,34.89 31.6,33.51 arc(31.54,33.22) 31.38,32.98 31.36,32.96 arc(31.12,32.8) 30.83,32.74 30.12,32.74 arc(29.64,32.64) 29.23,32.37 27.86,31 arc(26.75,30.26) 25.44,30 19.04,30 arc(18.92,29.97) 18.81,29.9 18.21,29.3 arc(18.13,29.19) 18.11,29.07 18.11,20.78 arc(17.99,20.5) 17.72,20.38 17.03,20.38 arc(16.84,20.19) 17.03,20 17.72,20 arc(17.99,19.89) 18.11,19.61 18.11,19.5 arc(18.08,19.34) 17.98,19.19 17.97,19.18 arc(17.83,19.08) 17.66,19.05 16.22,19.05 arc(15.95,19.16) 15.84,19.42 15.84,19.78 arc(15.65,19.97) 15.46,19.78 15.46,19.44 arc(15.07,19.05) 14.68,19.44 14.68,19.69 arc(14.59,19.89) 14.39,19.97 14.28,19.97 arc(14.15,19.92) 14.09,19.78 14.09,19.04 arc(13.7,18.64) 13.3,19.04 13.3,19.69 arc(13.22,19.89) 13.02,19.97 12.91,19.97 arc(12.78,19.92) 12.72,19.78 12.72,19.37 arc(12.33,18.97) 11.93,19.37 11.93,19.69 arc(11.84,19.91) 11.62,20 11.44,20 arc(11.21,19.95) 11.02,19.83 v1(10.84,19.64)
MIPI_DPHY_CSI0_RX_D3N: length 95.7
  TOP w0.084: v1(11.86,21.99) 11.71,21.84 arc(11.55,21.74) 11.37,21.7 7.6,21.7 arc(7.51,21.72) 7.43,21.77 7.42,21.78 arc(7.35,21.83) 7.26,21.85 J14.20 ; CN3.19 79.52,45.48 arc(79.53,45.42) 79.57,45.37 79.58,45.36 arc(79.61,45.31) 79.62,45.25 79.62,44.93 79.46,44.76 79.46,43.37 arc(79.31,42.61) 78.88,41.97 74.55,37.65 arc(73.82,37.16) 72.94,36.98 36.65,36.98 arc(36.21,36.89) 35.83,36.64 34.37,35.19 arc(34.07,34.99) 33.72,34.92 31.51,34.92 arc(31.3,34.96) 31.11,35.08 v1(30.93,35.26)
  ART03 w0.076: v1(30.93,35.26) 30.99,35.21 30.99,34.98 arc(30.94,34.86) 30.83,34.82 30.08,34.82 arc(29.5,34.7) 29,34.37 28.46,33.82 arc(28.19,33.42) 28.09,32.94 28.09,32.65 arc(28.07,32.53) 28,32.43 27.16,31.59 arc(26.55,31.34) 25.94,31.59 25.43,32.11 arc(24.93,32.31) 24.43,32.11 24.31,31.98 arc(23.21,31.24) 21.92,30.99 19.06,30.99 arc(18.48,30.87) 17.99,30.54 17.59,30.15 arc(17.26,29.65) 17.14,29.07 17.14,23.02 arc(17.07,22.85) 16.91,22.78 15.81,22.78 arc(15.42,22.39) 15.81,22 16.66,22 arc(16.77,21.95) 16.81,21.84 16.81,21.84 arc(16.74,21.67) 16.57,21.6 16.26,21.6 arc(15.98,21.48) 15.87,21.21 15.87,20.99 arc(15.68,20.8) 15.49,20.99 15.49,21.21 arc(15.09,21.6) 14.7,21.21 14.7,20.99 arc(14.51,20.8) 14.32,20.99 14.32,21.21 arc(14.2,21.48) 13.93,21.6 12.54,21.6 arc(12.29,21.65) 12.07,21.79 11.87,21.99 v1(11.86,21.99)
MIPI_DPHY_CSI0_RX_D3P: length 95.7
  TOP w0.084: J14.19 7.26,21.35 arc(7.35,21.37) 7.42,21.42 7.44,21.43 arc(7.51,21.48) 7.6,21.5 11.19,21.5 arc(11.45,21.45) 11.66,21.31 11.86,21.1 v1(11.87,21.1) ; v1(30.93,34.37) 31.11,34.55 arc(31.3,34.67) 31.51,34.72 33.72,34.72 arc(34.15,34.8) 34.51,35.05 35.97,36.5 arc(36.28,36.71) 36.65,36.78 72.94,36.78 arc(73.89,36.97) 74.69,37.51 79.02,41.83 arc(79.49,42.54) 79.65,43.37 79.65,44.68 79.82,44.85 79.82,45.25 arc(79.83,45.31) 79.87,45.36 79.88,45.37 arc(79.91,45.42) 79.92,45.48 CN3.21
  ART03 w0.076: v1(11.87,21.1) 12.02,21.26 arc(12.18,21.36) 12.36,21.4 13.93,21.4 arc(14.06,21.34) 14.12,21.21 14.12,20.99 arc(14.51,20.6) 14.9,20.99 14.9,21.21 arc(15.09,21.4) 15.29,21.21 15.29,20.99 arc(15.68,20.6) 16.07,20.99 16.07,21.21 arc(16.13,21.34) 16.26,21.4 16.57,21.4 arc(16.88,21.52) 17.02,21.83 arc(16.92,22.09) 16.66,22.2 15.81,22.2 arc(15.62,22.39) 15.81,22.58 16.91,22.58 arc(17.22,22.71) 17.35,23.02 17.35,29.07 arc(17.45,29.57) 17.74,30 18.13,30.4 arc(18.56,30.68) 19.06,30.78 21.92,30.78 arc(23.29,31.06) 24.45,31.83 24.58,31.96 arc(24.93,32.11) 25.28,31.96 25.8,31.45 arc(26.55,31.13) 27.3,31.45 28.15,32.29 arc(28.26,32.45) 28.3,32.65 28.3,32.94 arc(28.37,33.34) 28.6,33.68 29.15,34.23 arc(29.58,34.51) 30.08,34.61 30.53,34.61 arc(30.68,34.58) 30.81,34.5 v1(30.93,34.37)
MIPI_DPHY_CSI1_RX_CLKN: length 73.5
  TOP w0.084: v1(64.92,51.79) 64.92,51.6 arc(64.89,51.45) 64.8,51.32 64.63,51.15 arc(64.48,50.91) 64.42,50.64 64.42,49.65 arc(64.41,49.59) 64.38,49.54 64.37,49.53 arc(64.33,49.48) 64.32,49.42 CN2.62 ; J15.10 7.26,36.05 arc(7.35,36.03) 7.42,35.98 7.43,35.97 arc(7.51,35.92) 7.6,35.9 7.74,35.9 arc(7.87,35.93) 7.98,36 8.17,36.18 arc(8.37,36.48) 8.44,36.84 8.44,38.53 arc(8.53,39.01) 8.8,39.41 8.87,39.47 arc(9.09,39.81) 9.17,40.21 9.17,40.99 arc(9.31,41.68) 9.7,42.26 10.84,43.41 arc(11.43,43.8) 12.12,43.93 12.85,43.93 arc(13,43.96) 13.13,44.05 v1(13.26,44.18)
  BOTTOM w0.084: v1(13.26,44.18) 13.26,44.17 13.38,44.05 arc(13.51,43.96) 13.66,43.93 13.83,43.93 14.49,43.27 arc(14.53,43.24) 14.59,43.23 16.76,43.23 arc(17.14,43.15) 17.47,42.94 18.34,42.06 arc(18.82,41.74) 19.39,41.63 34.03,41.63 arc(34.59,41.74) 35.07,42.06 35.62,42.61 arc(36.17,42.97) 36.81,43.1 39.7,43.1 arc(40.34,42.97) 40.88,42.61 40.95,42.54 arc(41.43,42.22) 41.99,42.11 45.59,42.11 arc(46.15,42.22) 46.63,42.54 52.26,48.18 arc(52.81,48.54) 53.45,48.67 62.38,48.67 arc(62.94,48.78) 63.42,49.1 64.39,50.07 arc(64.43,50.12) 64.44,50.17 64.44,50.7 arc(64.49,50.98) 64.65,51.21 64.82,51.39 arc(64.9,51.5) 64.92,51.63 v1(64.92,51.79)
MIPI_DPHY_CSI1_RX_CLKP: length 73.6
  TOP w0.084: v1(64.92,50.79) 64.78,50.79 arc(64.67,50.74) 64.62,50.63 64.62,49.65 arc(64.63,49.59) 64.67,49.54 64.68,49.53 arc(64.71,49.48) 64.72,49.42 CN2.64 ; v1(13.26,43.29) 13.29,43.32 arc(13.35,43.46) 13.29,43.6 arc(13.15,43.7) 12.98,43.73 12.12,43.73 arc(11.5,43.61) 10.98,43.27 9.84,42.12 arc(9.49,41.6) 9.37,40.99 9.37,40.21 arc(9.27,39.73) 9.01,39.33 8.94,39.27 arc(8.72,38.93) 8.64,38.53 8.64,36.84 arc(8.55,36.41) 8.31,36.04 8.12,35.86 arc(7.95,35.74) 7.74,35.7 7.6,35.7 arc(7.51,35.68) 7.44,35.63 7.42,35.62 arc(7.35,35.57) 7.26,35.55 J15.9
  BOTTOM w0.084: v1(64.92,50.79) 64.73,50.79 64.63,50.69 64.63,50.03 64.48,49.88 arc(64.46,49.82) 64.48,49.76 arc(64.5,49.7) 64.48,49.65 64.36,49.52 arc(64.3,49.5) 64.24,49.52 arc(64.19,49.55) 64.13,49.52 63.56,48.96 arc(63.02,48.6) 62.38,48.47 53.45,48.47 arc(52.88,48.36) 52.4,48.04 46.77,42.4 arc(46.23,42.04) 45.59,41.91 41.99,41.91 arc(41.35,42.04) 40.81,42.4 40.74,42.47 arc(40.26,42.79) 39.7,42.9 36.81,42.9 arc(36.24,42.79) 35.76,42.47 35.21,41.92 arc(34.67,41.55) 34.03,41.43 19.39,41.43 arc(18.75,41.55) 18.2,41.92 17.33,42.8 arc(17.06,42.97) 16.76,43.03 16.47,43.03 arc(16.42,43.01) 16.4,42.97 arc(16.38,42.92) 16.33,42.9 16.13,42.9 arc(16.08,42.92) 16.07,42.97 arc(16.05,43.01) 16,43.03 15.8,43.03 arc(15.75,43.01) 15.73,42.97 arc(15.71,42.92) 15.66,42.9 15.46,42.9 arc(15.41,42.92) 15.39,42.97 arc(15.38,43.01) 15.33,43.03 15.13,43.03 arc(15.08,43.01) 15.06,42.97 arc(15.04,42.92) 14.99,42.9 14.79,42.9 arc(14.74,42.92) 14.72,42.97 arc(14.71,43.01) 14.66,43.03 14.45,43.03 14.3,43.18 arc(14.23,43.21) 14.16,43.18 arc(14.09,43.15) 14.02,43.18 13.92,43.28 arc(13.89,43.35) 13.92,43.42 13.92,43.42 arc(13.95,43.49) 13.92,43.56 13.75,43.73 13.36,43.73 arc(13.23,43.68) 13.18,43.56 13.18,43.43 arc(13.19,43.37) 13.23,43.32 v1(13.26,43.29)
