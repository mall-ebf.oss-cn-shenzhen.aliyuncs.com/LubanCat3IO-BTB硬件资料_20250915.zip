# Allegro board EBF410588V1R0_PCB_20251110.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART10_RX: length 6.4
  BOTTOM w0.152: J28.3 122.4,7.29 121.98,7.71 D40.2 119.97,8.39 R201.2
UART10_RX_M1: length 68.8
  TOP w0.152: CN4.58 63.52,11.08 63.91,10.69 69.93,10.69 70.48,11.25 74.88,11.25 76.35,9.78 94.54,9.78 95.55,10.79 95.55,15.37 97.71,17.53 103.53,17.53 105.64,15.42 105.64,12.64 v1(106.16,12.12)
  BOTTOM w0.152: v1(106.16,12.12) 106.65,11.63 114.58,11.63 116.03,10.19 118.95,10.19 119.25,9.88 R201.1
UART10_TX: length 7.9
  BOTTOM w0.152: J28.4 123.52,3.06 123.52,7.64 D39.2 122.77,8.39 R202.2
UART10_TX_M1: length 72.6
  TOP w0.152: CN4.56 63.12,10.94 63.68,10.39 70.05,10.39 70.61,10.95 74.75,10.95 76.25,9.45 94.95,9.45 95.99,10.49 95.99,15.14 97.92,17.07 103.28,17.07 105.18,15.16 105.18,12.32 105.89,11.61 106.65,11.61 v1(107.16,12.12)
  BOTTOM w0.152: R202.1 122.05,10.01 121.36,10.69 116.24,10.69 114.81,12.12 v1(107.16,12.12)
USB2_OTG0_DM: length 79.7
  TOP w0.109: CN3.40 83.52,49.52 83.6,49.6 83.6,50.71 v1(83.52,50.79) ; R108.2 27.66,76.75 arc(27.77,76.57) 27.82,76.36 27.82,75.54 arc(27.75,75.38) 27.58,75.31 v1(27.49,75.31)
  ART03 w0.089: v1(34.15,61.26) 34.15,61.48 arc(34.1,61.62) 33.97,61.67 33.74,61.67 arc(33.55,61.71) 33.39,61.82 32.19,63.02 arc(32,63.31) 31.93,63.65 31.93,69.51 arc(31.87,69.78) 31.72,70 30.3,71.43 arc(30.1,71.72) 30.04,72.06 30.04,72.35 arc(29.98,72.62) 29.83,72.85 28.08,74.6 arc(27.98,74.74) 27.95,74.91 27.95,75.15 arc(27.9,75.26) 27.79,75.31 v1(27.49,75.31)
  BOTTOM w0.109: v1(83.52,50.79) 83.52,50.94 arc(83.5,51.06) 83.43,51.17 83.2,51.4 arc(83.04,51.64) 82.98,51.92 82.98,53.14 arc(83.03,53.39) 83.18,53.61 83.29,53.72 arc(83.38,53.86) 83.41,54.02 83.41,55.51 arc(83.28,56.18) 82.9,56.75 82.44,57.2 arc(81.99,57.51) 81.46,57.61 73.4,57.61 arc(73.15,57.66) 72.93,57.81 72.59,58.15 arc(72.29,58.35) 71.94,58.42 59.78,58.42 arc(59.44,58.35) 59.15,58.16 58.71,57.72 arc(58.5,57.58) 58.26,57.53 53.17,57.53 arc(53.04,57.51) 52.93,57.43 52.34,56.84 arc(52.15,56.72) 51.93,56.67 45.47,56.67 arc(44.83,56.8) 44.29,57.16 41.39,60.06 arc(40.78,60.47) 40.06,60.61 37.49,60.61 arc(37.25,60.66) 37.05,60.79 36.36,61.48 arc(36.24,61.56) 36.1,61.59 34.31,61.59 arc(34.2,61.54) 34.15,61.43 v1(34.15,61.26)
USB2_OTG0_DP: length 79.2
  TOP w0.109: v1(28.39,75.31) 28.22,75.48 arc(28.11,75.66) 28.06,75.86 28.06,76.36 arc(28.11,76.57) 28.22,76.75 R107.2 ; CN3.42 83.92,49.52 83.85,49.6 83.85,50.35 arc(83.87,50.44) 83.92,50.52 84,50.6 arc(84.08,50.79) 84,50.97 83.63,51.34 arc(83.55,51.46) 83.52,51.61 v1(83.52,51.79)
  ART03 w0.089: v1(34.15,62.12) 33.98,61.95 arc(33.88,61.88) 33.76,61.86 33.74,61.86 arc(33.63,61.88) 33.53,61.95 32.32,63.16 arc(32.17,63.38) 32.12,63.65 32.12,69.51 arc(32.05,69.85) 31.86,70.14 30.43,71.57 arc(30.28,71.79) 30.23,72.06 30.23,72.35 arc(30.16,72.69) 29.97,72.98 28.22,74.73 arc(28.16,74.81) 28.14,74.91 28.14,74.94 arc(28.16,75.05) 28.22,75.14 v1(28.39,75.31)
  BOTTOM w0.109: v1(34.15,62.12) 34.3,61.97 arc(34.45,61.87) 34.62,61.84 36.1,61.84 arc(36.34,61.79) 36.54,61.66 37.23,60.97 arc(37.35,60.89) 37.49,60.86 40.06,60.86 arc(40.88,60.7) 41.57,60.23 44.47,57.34 arc(44.93,57.03) 45.47,56.92 51.93,56.92 arc(52.06,56.95) 52.17,57.02 52.76,57.61 arc(52.95,57.74) 53.17,57.78 58.26,57.78 arc(58.41,57.81) 58.53,57.89 58.98,58.34 arc(59.34,58.58) 59.78,58.67 71.94,58.67 arc(72.38,58.58) 72.76,58.33 73.11,57.98 arc(73.24,57.89) 73.4,57.86 81.46,57.86 arc(82.09,57.74) 82.62,57.38 83.07,56.93 arc(83.51,56.28) 83.66,55.51 83.66,54.02 arc(83.61,53.76) 83.47,53.55 83.35,53.43 arc(83.26,53.3) 83.23,53.14 83.23,51.92 arc(83.27,51.83) 83.37,51.79 v1(83.52,51.79)
USB2_OTG0_ID: length 7
  TOP w0.152: CN3.30 81.52,50.15 81.9,50.54 81.9,50.81 v1(81.88,50.84)
  BOTTOM w0.152: v1(81.88,50.84) 81.39,51.33 81.39,53.23 80.77,53.85 80.77,54.6 R104.2
USB2_OTG0_VBUSDET: length 6.9
  TOP w0.152: CN3.32 81.92,49.5 81.84,49.58 81.84,50.01 82.42,50.6 82.42,51.29 v1(81.89,51.82)
  BOTTOM w0.152: R103.2 81.9,54.48 81.9,51.83 v1(81.89,51.82)
USB2_OTG1_DM: length 47.9
  TOP w0.109: R132.1 124.41,54.67 arc(124.54,54.47) 124.59,54.23 124.59,53.42 arc(124.39,52.95) 123.92,52.75 116.72,52.75 arc(116.18,52.86) 115.72,53.17 115.63,53.25 arc(115.09,53.61) 114.45,53.74 109.79,53.74 arc(109.14,53.61) 108.6,53.25 108.21,52.86 arc(108.09,52.78) 107.95,52.75 83.79,52.75 arc(83.42,52.68) 83.1,52.47 83.08,52.45 arc(82.87,52.13) 82.8,51.76 82.8,49.6 82.72,49.52 CN3.36
USB2_OTG1_DP: length 47.9
  TOP w0.109: R131.1 125.02,54.67 arc(124.89,54.47) 124.84,54.23 124.84,53.42 arc(124.57,52.77) 123.92,52.5 116.72,52.5 arc(116.08,52.63) 115.54,52.99 115.46,53.07 arc(115,53.38) 114.45,53.49 109.79,53.49 arc(109.24,53.38) 108.78,53.07 108.39,52.68 arc(108.18,52.55) 107.95,52.5 83.79,52.5 arc(83.51,52.45) 83.28,52.29 83.26,52.27 arc(83.1,52.04) 83.05,51.76 83.05,49.6 83.12,49.52 CN3.38
USB2_OTG1_ID: length 5.4
  TOP w0.152: v1(80.61,43.11) 81.12,43.63 CN3.27
  BOTTOM w0.152: R137.2 80.12,44.7 80.12,43.6 v1(80.61,43.11)
USB2_OTG1_VBUSDET: length 3.3
  TOP w0.152: CN3.25 80.72,44.23 v1(80.61,44.11)
  BOTTOM w0.152: v1(80.61,44.11) 80.61,44.16 R136.2
USB3_OTG0_SSRX1N: length 107
  TOP w0.109: CN3.43 84.32,45.38 84.4,45.3 84.4,41.74 arc(84.25,41) 83.83,40.37 77.21,33.75 arc(76.58,33.33) 75.84,33.18 41.98,33.18 arc(41.15,33.01) 40.44,32.54 40.17,32.27 arc(39.72,31.97) 39.19,31.87 38.72,31.87 arc(38.53,31.9) 38.37,32.01 v1(38.2,32.17) ; R113.2 32.67,76.75 arc(32.55,76.57) 32.51,76.36 32.51,75.86 arc(32.55,75.66) 32.67,75.48 v1(32.84,75.31)
  ART03 w0.089: v1(38.2,32.17) 38.45,31.93 arc(38.55,31.86) 38.67,31.84 38.72,31.84 arc(38.81,31.86) 38.9,31.91 39.64,32.66 arc(39.99,33.17) 40.11,33.78 40.11,37.35 arc(40.05,37.62) 39.9,37.85 36.17,41.57 arc(36.05,41.76) 36,41.98 36,47.15 arc(36.05,47.37) 36.17,47.55 36.58,47.96 arc(36.68,48.11) 36.72,48.29 36.72,48.31 arc(36.68,48.5) 36.58,48.65 36.47,48.76 arc(36.34,48.95) 36.3,49.17 36.3,61.97 arc(36.24,62.23) 36.09,62.46 34.5,64.05 arc(34.16,64.57) 34.04,65.17 34.04,71.33 arc(34.02,71.39) 33.98,71.45 33.52,71.91 arc(33.39,72.1) 33.35,72.33 33.35,75.44 arc(33.31,75.63) 33.2,75.8 33.19,75.81 arc(33.03,75.92) 32.84,75.96 32.67,75.96 arc(32.47,75.88) 32.38,75.69 arc(32.38,75.68) 32.38,75.67 32.38,75.47 arc(32.43,75.36) 32.54,75.31 v1(32.84,75.31)
USB3_OTG0_SSRX1P: length 107.9
  TOP w0.109: R112.2 32.1,76.75 arc(32.22,76.57) 32.26,76.36 32.26,75.86 arc(32.22,75.66) 32.1,75.48 v1(31.93,75.31) ; CN3.45 84.72,45.38 84.65,45.3 84.65,41.74 arc(84.48,40.9) 84.01,40.2 77.38,33.57 arc(76.67,33.1) 75.84,32.93 41.98,32.93 arc(41.24,32.78) 40.62,32.36 40.35,32.1 arc(39.82,31.74) 39.19,31.62 38.72,31.62 arc(38.53,31.58) 38.37,31.47 v1(38.2,31.31)
  ART03 w0.089: v1(38.2,31.31) 38.42,31.53 arc(38.55,31.62) 38.71,31.65 38.72,31.65 arc(38.89,31.68) 39.03,31.78 39.78,32.52 arc(40.16,33.1) 40.3,33.78 40.3,37.35 arc(40.23,37.69) 40.04,37.98 36.31,41.71 arc(36.22,41.84) 36.2,41.98 36.2,47.15 arc(36.22,47.29) 36.3,47.41 36.71,47.82 arc(36.86,48.04) 36.91,48.29 36.91,48.31 arc(36.86,48.57) 36.71,48.79 36.6,48.89 arc(36.52,49.02) 36.49,49.17 36.49,61.97 arc(36.42,62.31) 36.23,62.59 34.63,64.19 34.63,64.19 arc(34.33,64.64) 34.23,65.17 34.23,71.33 arc(34.2,71.47) 34.12,71.59 33.66,72.05 arc(33.57,72.18) 33.54,72.33 33.54,75.44 arc(33.49,75.71) 33.34,75.93 33.32,75.95 arc(33.1,76.1) 32.84,76.15 32.67,76.15 arc(32.34,76.02) 32.19,75.71 32.19,75.71 arc(32.15,75.56) 32.07,75.44 v1(31.93,75.31)
USB3_OTG0_SSRX2N: length 101.5
  TOP w0.109: v1(25.98,75.31) 25.81,75.48 arc(25.69,75.66) 25.65,75.86 25.65,76.36 arc(25.69,76.57) 25.81,76.75 R117.2 ; v1(38.21,34.68) 38.21,34.54 arc(38.26,34.42) 38.37,34.37 38.91,34.37 arc(39.01,34.39) 39.1,34.45 39.17,34.52 arc(39.34,34.64) 39.54,34.68 74.75,34.68 arc(75.49,34.83) 76.12,35.25 82.23,41.36 arc(82.65,41.99) 82.8,42.73 82.8,45.3 82.72,45.38 CN3.35
  ART03 w0.089: v1(25.98,75.31) 25.79,75.31 arc(25.67,75.26) 25.62,75.14 25.62,74.77 25.62,74.63 arc(25.67,74.41) 25.79,74.22 26.26,73.75 arc(26.76,73.42) 27.34,73.3 27.74,73.3 arc(28.1,73.23) 28.41,73.03 28.43,73.01 arc(28.63,72.71) 28.7,72.34 28.7,71.05 arc(28.76,70.79) 28.91,70.56 30.7,68.76 arc(30.89,68.48) 30.96,68.14 30.96,61.9 arc(31.02,61.63) 31.17,61.41 33.59,58.98 arc(33.98,58.4) 34.11,57.72 34.11,41.95 arc(34.23,41.34) 34.58,40.83 36.92,38.48 arc(37.31,37.91) 37.44,37.23 37.44,34.47 arc(37.51,34.31) 37.67,34.24 37.95,34.24 arc(38.04,34.26) 38.12,34.31 38.13,34.32 arc(38.19,34.4) 38.21,34.5 v1(38.21,34.68)
USB3_OTG0_SSRX2P: length 101.6
  TOP w0.109: CN3.37 83.12,45.38 83.05,45.3 83.05,42.73 arc(82.88,41.89) 82.41,41.18 76.29,35.07 arc(75.58,34.6) 74.75,34.43 39.54,34.43 arc(39.44,34.41) 39.35,34.35 39.28,34.28 arc(39.11,34.16) 38.91,34.12 38.72,34.12 arc(38.53,34.08) 38.37,33.98 v1(38.21,33.82) ; R114.2 25.24,76.75 arc(25.36,76.57) 25.4,76.36 25.4,75.86 arc(25.36,75.66) 25.25,75.48 v1(25.07,75.31)
  ART03 w0.089: v1(25.07,75.31) 25.26,75.12 arc(25.39,74.93) 25.43,74.71 25.43,74.63 arc(25.49,74.34) 25.66,74.09 26.13,73.62 arc(26.69,73.24) 27.34,73.11 27.74,73.11 arc(28.03,73.06) 28.28,72.89 28.29,72.88 arc(28.45,72.63) 28.51,72.34 28.51,71.05 arc(28.58,70.71) 28.77,70.43 30.57,68.63 arc(30.72,68.4) 30.77,68.14 30.77,61.9 arc(30.84,61.56) 31.03,61.27 33.46,58.85 arc(33.8,58.33) 33.92,57.72 33.92,41.95 arc(34.06,41.27) 34.44,40.69 36.79,38.35 arc(37.13,37.83) 37.25,37.23 37.25,34.47 arc(37.37,34.17) 37.67,34.05 37.82,34.05 arc(37.96,34.02) 38.08,33.94 v1(38.21,33.82)
USB3_OTG0_SSTX1N: length 105.2
  TOP w0.109: C100.2 30.07,76.75 arc(30.19,76.57) 30.23,76.36 30.23,75.86 arc(30.19,75.66) 30.07,75.48 v1(29.9,75.31) ; v1(36.6,33.26) 36.82,33.04 arc(36.92,32.97) 37.04,32.95 38.76,32.95 arc(39.3,33.06) 39.77,33.37 39.84,33.44 arc(40.38,33.8) 41.02,33.93 75.29,33.93 arc(76.04,34.08) 76.66,34.5 83.03,40.86 arc(83.45,41.49) 83.6,42.23 83.6,45.3 83.52,45.38 CN3.39
  ART03 w0.089: v1(36.6,33.26) 36.6,33.02 arc(36.65,32.9) 36.78,32.84 37.53,32.84 arc(38.07,32.95) 38.53,33.26 38.65,33.38 arc(39,33.9) 39.12,34.51 39.12,37 arc(39.06,37.26) 38.91,37.49 35.56,40.84 arc(35.17,41.42) 35.04,42.1 35.04,61.25 arc(34.92,61.86) 34.57,62.38 33.36,63.59 arc(33.16,63.88) 33.1,64.22 33.1,70.15 arc(33.04,70.42) 32.89,70.65 31.73,71.81 arc(31.54,72.1) 31.47,72.44 31.47,73.14 arc(31.42,73.41) 31.27,73.64 30.56,74.34 arc(30.41,74.56) 30.36,74.83 30.36,75.09 arc(30.29,75.24) 30.14,75.31 v1(29.9,75.31)
USB3_OTG0_SSTX1P: length 105.4
  TOP w0.109: v1(30.81,75.31) 30.63,75.48 arc(30.52,75.66) 30.48,75.86 30.48,76.36 arc(30.52,76.57) 30.64,76.75 C99.2 ; v1(36.6,32.39) 36.76,32.55 arc(36.92,32.66) 37.11,32.7 38.76,32.7 arc(39.4,32.83) 39.94,33.19 40.02,33.26 arc(40.48,33.57) 41.02,33.68 75.29,33.68 arc(76.13,33.85) 76.84,34.32 83.21,40.69 arc(83.68,41.4) 83.85,42.23 83.85,45.3 83.92,45.38 CN3.41
  ART03 w0.089: v1(36.6,32.39) 36.74,32.53 arc(36.87,32.62) 37.04,32.65 37.53,32.65 arc(38.14,32.78) 38.66,33.12 38.79,33.25 arc(39.17,33.83) 39.31,34.51 39.31,37 arc(39.24,37.34) 39.05,37.63 35.69,40.98 arc(35.35,41.49) 35.23,42.1 35.23,61.25 arc(35.09,61.94) 34.71,62.51 33.49,63.73 arc(33.34,63.96) 33.29,64.22 33.29,70.15 arc(33.22,70.5) 33.03,70.78 31.87,71.94 arc(31.71,72.17) 31.66,72.44 31.66,73.14 arc(31.59,73.48) 31.4,73.77 30.69,74.48 arc(30.59,74.64) 30.55,74.83 30.55,74.88 arc(30.58,75.04) 30.67,75.17 v1(30.81,75.31)
USB3_OTG0_SSTX2N: length 102.8
  TOP w0.109: v1(36.62,35.35) 36.62,35.21 arc(36.7,35.02) 36.89,34.95 37.08,34.95 arc(37.24,34.98) 37.38,35.07 37.59,35.28 arc(37.78,35.41) 38.01,35.45 74.42,35.45 arc(74.53,35.48) 74.63,35.54 81.91,42.82 arc(81.98,42.92) 82,43.03 82,45.3 81.92,45.38 CN3.31 ; C102.2 23.25,76.71 arc(23.34,76.57) 23.37,76.41 23.37,75.81 arc(23.34,75.65) 23.25,75.52 v1(23.04,75.31)
  ART03 w0.089: v1(36.62,35.35) 36.34,35.07 arc(36.28,35.03) 36.21,35.02 36.03,35.02 arc(35.87,35.08) 35.8,35.25 35.8,37.55 arc(35.67,38.23) 35.28,38.81 33.74,40.35 arc(33.39,40.87) 33.27,41.48 33.27,49.41 arc(33.18,49.9) 32.9,50.31 32.73,50.48 arc(32.58,50.71) 32.52,50.98 32.52,58.08 arc(32.46,58.42) 32.26,58.71 29.96,61.01 arc(29.81,61.24) 29.76,61.51 29.76,68.09 arc(29.69,68.43) 29.5,68.72 23.93,74.28 arc(23.65,74.47) 23.32,74.54 23.27,74.54 arc(22.99,74.59) 22.75,74.75 22.73,74.77 arc(22.57,75.01) 22.52,75.29 22.52,75.42 arc(22.56,75.64) 22.69,75.84 22.71,75.85 arc(22.8,75.91) 22.9,75.93 23.19,75.93 arc(23.33,75.88) 23.4,75.75 arc(23.4,75.73) 23.4,75.71 23.4,75.5 arc(23.35,75.36) 23.21,75.31 v1(23.04,75.31)
USB3_OTG0_SSTX2P: length 103.8
  TOP w0.109: CN3.33 82.32,45.38 82.25,45.3 82.25,43.03 arc(82.21,42.82) 82.09,42.65 74.81,35.36 arc(74.63,35.25) 74.42,35.2 38.01,35.2 arc(37.88,35.18) 37.77,35.1 37.55,34.89 arc(37.34,34.75) 37.08,34.7 36.96,34.7 arc(36.84,34.67) 36.73,34.6 v1(36.62,34.49) ; v1(23.95,75.31) 23.9,75.31 23.77,75.44 arc(23.66,75.61) 23.62,75.81 23.62,76.41 arc(23.65,76.57) 23.74,76.71 C101.2
  ART03 w0.089: v1(36.62,34.49) 36.34,34.77 arc(36.28,34.81) 36.21,34.82 36.03,34.82 arc(35.73,34.95) 35.61,35.25 35.61,37.55 arc(35.49,38.16) 35.15,38.68 33.6,40.22 arc(33.22,40.79) 33.08,41.48 33.08,49.41 arc(33,49.82) 32.76,50.18 32.59,50.35 arc(32.4,50.63) 32.33,50.98 32.33,58.08 arc(32.28,58.35) 32.13,58.57 29.83,60.88 arc(29.63,61.17) 29.57,61.51 29.57,68.09 arc(29.51,68.35) 29.36,68.58 23.79,74.15 arc(23.58,74.29) 23.32,74.35 23.27,74.35 arc(22.91,74.42) 22.61,74.62 22.6,74.63 arc(22.4,74.93) 22.33,75.29 22.33,75.42 arc(22.39,75.72) 22.56,75.97 22.57,75.99 arc(22.72,76.09) 22.9,76.12 23.19,76.12 arc(23.45,76.03) 23.58,75.78 23.6,75.78 arc(23.64,75.65) 23.72,75.54 v1(23.95,75.31)
USB3_OTG1_SSRXN: length 104
  TOP w0.109: v1(60.06,26.86) 60.15,26.86 arc(60.21,26.87) 60.26,26.91 60.57,27.22 arc(60.69,27.3) 60.84,27.33 60.93,27.33 arc(61.01,27.35) 61.09,27.4 61.09,27.4 arc(61.24,27.5) 61.4,27.53 98.33,27.53 arc(99.19,27.7) 99.92,28.19 107.04,35.3 arc(107.72,36.32) 107.96,37.52 107.96,47.94 arc(108.06,48.48) 108.37,48.93 109.57,50.13 arc(110.14,50.52) 110.83,50.65 113.16,50.65 arc(113.28,50.68) 113.38,50.74 113.49,50.85 v1(113.49,50.96) ; R110.2 112.25,68.73 arc(112.38,68.54) 112.42,68.33 112.42,68.25 arc(112.39,68.08) 112.29,67.93 v1(112.14,67.79) ; CN4.37 59.52,15.25 59.6,15.32 59.6,16.31 arc(59.66,16.65) 59.85,16.93 60.02,17.1 arc(60.1,17.21) 60.12,17.34 v1(60.12,17.51)
  ART03 w0.089: v1(113.49,50.96) 113.49,50.77 arc(113.53,50.67) 113.64,50.62 114.07,50.62 arc(114.21,50.65) 114.34,50.73 114.72,51.12 arc(115.07,51.64) 115.19,52.25 115.19,63.59 arc(115.07,64.2) 114.72,64.71 112.67,66.76 arc(112.53,66.98) 112.48,67.23 112.48,67.61 arc(112.43,67.74) 112.3,67.79 v1(112.14,67.79) ; v1(60.12,17.51) 60.26,17.64 arc(60.36,17.79) 60.39,17.95 60.39,26.31 arc(60.35,26.52) 60.23,26.69 v1(60.06,26.86)
USB3_OTG1_SSRXP: length 103
  TOP w0.109: v1(60.9,26.86) 61.27,27.23 arc(61.33,27.27) 61.4,27.28 98.33,27.28 arc(99.29,27.47) 100.1,28.01 107.21,35.13 arc(107.95,36.23) 108.2,37.52 108.2,47.94 arc(108.29,48.38) 108.54,48.76 109.74,49.95 arc(110.24,50.29) 110.83,50.4 113.05,50.4 arc(113.17,50.38) 113.27,50.31 v1(113.49,50.1) ; v1(113,67.79) 112.83,67.96 arc(112.71,68.14) 112.67,68.35 112.67,68.38 arc(112.71,68.59) 112.83,68.77 R111.2 ; CN4.39 59.92,15.25 59.85,15.32 59.85,16.05 arc(59.88,16.22) 59.98,16.36 v1(60.12,16.51)
  ART03 w0.089: v1(60.9,26.86) 60.85,26.86 60.78,26.79 arc(60.63,26.57) 60.58,26.32 60.58,17.5 arc(60.55,17.34) 60.45,17.2 60.24,16.99 arc(60.15,16.85) 60.12,16.69 v1(60.12,16.51) ; v1(113.49,50.1) 113.66,50.27 arc(113.84,50.39) 114.05,50.43 114.07,50.43 arc(114.29,50.48) 114.47,50.6 114.86,50.99 arc(115.24,51.56) 115.38,52.25 115.38,63.59 arc(115.24,64.27) 114.86,64.85 112.81,66.9 arc(112.7,67.05) 112.67,67.23 112.67,67.25 arc(112.7,67.44) 112.81,67.59 v1(113,67.79)
USB3_OTG1_SSTXN: length 109.2
  TOP w0.109: v1(119,67.79) 119.15,67.94 arc(119.25,68.09) 119.28,68.26 119.28,68.33 arc(119.24,68.54) 119.12,68.72 C97.2 ; v1(59.12,17.51) 59.12,17.32 arc(59.09,17.17) 59.01,17.05 58.75,16.79 arc(58.69,16.69) 58.66,16.57 58.66,16.07 arc(58.68,15.99) 58.72,15.93 58.74,15.91 arc(58.78,15.84) 58.8,15.76 58.8,15.32 58.72,15.25 CN4.33 ; v1(116.89,50.96) 116.68,50.75 arc(116.57,50.68) 116.45,50.65 116.22,50.65 arc(116.06,50.68) 115.93,50.77 115.19,51.51 arc(114.63,51.88) 113.97,52.01 110.78,52.01 arc(109.95,51.85) 109.24,51.37 109.24,51.37 107.93,50.07 arc(107.27,49.08) 107.04,47.91 107.04,37.66 arc(106.88,36.83) 106.4,36.12 99,28.72 arc(98.67,28.5) 98.28,28.42 59.71,28.42 arc(59.43,28.36) 59.19,28.21 58.91,27.92 arc(58.85,27.88) 58.77,27.86 v1(58.67,27.86)
  ART03 w0.089: v1(58.67,27.86) 58.9,27.63 arc(58.97,27.53) 58.99,27.41 58.99,27.4 arc(59.03,27.22) 59.13,27.06 59.25,26.94 arc(59.36,26.78) 59.4,26.59 59.4,17.97 arc(59.36,17.8) 59.27,17.65 v1(59.12,17.51) ; v1(116.89,50.96) 117.01,50.84 arc(117.14,50.75) 117.28,50.73 117.32,50.73 arc(117.56,50.82) 117.66,51.06 117.66,63.16 arc(117.79,63.84) 118.18,64.42 118.87,65.11 arc(119.21,65.63) 119.34,66.24 119.34,67.22 arc(119.29,67.43) 119.17,67.61 v1(119,67.79)
USB3_OTG1_SSTXP: length 109.1
  TOP w0.109: v1(116.89,50.1) 116.89,50.16 arc(116.88,50.22) 116.85,50.27 116.77,50.34 arc(116.7,50.39) 116.62,50.4 116.22,50.4 arc(115.97,50.45) 115.75,50.6 115.02,51.33 arc(114.54,51.65) 113.97,51.77 110.78,51.77 arc(110.04,51.62) 109.42,51.2 108.11,49.89 arc(107.5,48.98) 107.29,47.91 107.29,37.66 arc(107.11,36.73) 106.58,35.95 99.18,28.54 arc(98.76,28.27) 98.28,28.17 60.02,28.17 arc(59.83,28.13) 59.67,28.02 v1(59.51,27.86) ; CN4.35 59.12,15.25 59.05,15.32 59.05,16.43 v1(59.12,16.51) ; C98.2 119.7,68.78 arc(119.58,68.6) 119.53,68.37 119.53,67.9 arc(119.56,67.82) 119.64,67.79 v1(119.86,67.79)
  ART03 w0.089: v1(119.86,67.79) 119.68,67.79 arc(119.57,67.74) 119.53,67.63 119.53,66.24 arc(119.39,65.56) 119.01,64.98 118.31,64.29 arc(117.97,63.77) 117.85,63.16 117.85,51.06 arc(117.69,50.69) 117.32,50.53 117.17,50.53 arc(117.07,50.51) 116.98,50.46 116.97,50.45 arc(116.91,50.36) 116.89,50.26 v1(116.89,50.1) ; v1(59.12,16.51) 59.12,16.69 arc(59.15,16.84) 59.24,16.98 59.46,17.2 arc(59.56,17.34) 59.59,17.5 59.59,26.59 arc(59.54,26.85) 59.39,27.07 59.27,27.2 arc(59.2,27.29) 59.18,27.4 59.18,27.42 arc(59.2,27.53) 59.27,27.62 v1(59.51,27.86)
USB20_DM2: length 9.4
  TOP w0.109: R115.1 117.86,69.98 U15.2 U15.9 117.86,72.63 arc(117.85,72.7) 117.81,72.76 117.79,72.78 arc(117.75,72.84) 117.74,72.91 117.74,73.47 arc(117.6,73.8) 117.27,73.94 116.31,73.94 arc(116.15,74.01) 116.08,74.17 116.08,74.29 arc(116.14,74.6) 116.31,74.86 116.74,75.29 arc(116.89,75.64) 116.74,76 116.47,76.26 arc(116.41,76.36) 116.38,76.48 116.38,76.72 arc(116.41,76.85) 116.48,76.96 116.59,77.07 arc(116.72,77.15) 116.86,77.18 J11.11
USB20_DP2: length 9.1
  TOP w0.109: J11.12 114.96,75.9 arc(115.03,75.52) 115.25,75.2 115.46,74.99 115.55,74.9 115.7,74.75 115.77,74.68 arc(115.81,74.61) 115.83,74.54 115.83,74.17 arc(115.97,73.83) 116.31,73.69 117.27,73.69 arc(117.43,73.63) 117.49,73.47 117.49,72.91 arc(117.48,72.84) 117.43,72.78 117.42,72.76 arc(117.38,72.7) 117.36,72.63 U15.10 U15.1 117.36,70.85 arc(117.3,70.52) 117.11,70.24 R116.1
USB20_HOST_PWR_EN: length 126.7
  TOP w0.152: v1(60.92,43.11) 61.44,43.63 61.44,44.31 61.52,44.4 CN2.47
  ART03 w0.152: v1(128.14,85.75) 125.88,85.75 125.04,84.91 125.04,74.55 122.94,72.44 122.94,70.43 124.38,68.99 124.38,66.52 122.94,65.07 122.94,56.26 124.05,55.14 124.05,52.59 v1(122.67,51.21)
  BOTTOM w0.152: v1(122.67,51.21) 122.12,50.66 122.12,37.19 119.48,34.54 98.78,34.54 98.09,33.86 96.77,33.86 96.49,34.14 66.9,34.14 61.44,39.59 61.44,42.59 v1(60.92,43.11) ; R134.1 v1(128.14,85.75)
USB30_DM: length 13.2
  TOP w0.109: J11.2 116.9,80.44 arc(116.56,80.58) 116.22,80.44 116.07,80.29 arc(116.04,80.24) 116.03,80.18 116.03,80.17 arc(116,80.03) 115.92,79.91 115.1,79.09 arc(115.01,78.97) 114.99,78.82 114.99,78.7 arc(114.94,78.46) 114.8,78.25 114.14,77.59 arc(114.03,77.43) 114,77.24 114,77.12 arc(113.94,76.84) 113.78,76.59 113.13,75.95 arc(112.98,75.58) 113.13,75.21 114,74.34 arc(114.3,73.88) 114.41,73.34 114.41,72.91 arc(114.43,72.84) 114.47,72.78 114.48,72.76 arc(114.52,72.7) 114.54,72.63 U17.6 U17.5 114.54,70.85 arc(114.6,70.52) 114.79,70.24 R105.1
USB30_DP: length 12.9
  TOP w0.109: J11.3 115.65,80.38 arc(115.69,80.37) 115.73,80.35 115.74,80.33 arc(115.77,80.29) 115.78,80.25 115.78,80.17 arc(115.77,80.13) 115.74,80.09 114.92,79.27 arc(114.79,79.06) 114.74,78.82 114.74,78.7 arc(114.71,78.55) 114.62,78.43 113.97,77.77 arc(113.8,77.53) 113.75,77.24 113.75,77.12 arc(113.71,76.93) 113.6,76.77 112.96,76.13 arc(112.73,75.58) 112.96,75.03 113.82,74.17 arc(114.07,73.79) 114.16,73.34 114.16,72.91 arc(114.15,72.84) 114.11,72.78 114.09,72.76 arc(114.05,72.7) 114.04,72.63 U17.7 U17.4 114.04,69.98 R106.1
USB30_HOST_PWR_EN: length 132.6
  TOP w0.152: CN2.49 v1(61.92,44.11)
  ART03 w0.152: v1(121.67,51.21) 123.67,53.21 123.67,54.99 122.61,56.05 122.61,65.23 123.95,66.57 123.95,68.88 122.61,70.23 122.61,72.58 124.71,74.69 124.71,84.94 123.77,85.88 112.88,85.88 v1(112.78,85.78)
  BOTTOM w0.152: v1(121.67,51.21) 121.67,37.47 119.23,35.03 67.26,35.03 62.31,39.98 62.31,43.73 v1(61.92,44.11) ; R121.1 v1(112.78,85.78)
USB30_RXN: length 19.9
  TOP w0.109: R110.1 112.28,70.24 arc(112.47,70.52) 112.54,70.85 U17.1 U17.10 112.54,72.63 arc(112.55,72.7) 112.59,72.76 112.61,72.78 arc(112.65,72.84) 112.66,72.91 112.66,73.72 arc(112.47,74.18) 112.01,74.37 108.31,74.37 arc(107.54,74.69) 107.22,75.46 107.22,77.46 arc(107.38,78.3) 107.86,79 108.08,79.23 arc(109.22,79.7) 110.36,79.23 111.33,78.25 arc(111.5,78.14) 111.69,78.1 111.76,78.1 arc(111.92,78.13) 112.06,78.22 112.06,78.23 arc(112.18,78.5) 112.06,78.77 J11.5
USB30_RXP: length 20.8
  TOP w0.109: R111.1 113.04,69.98 U17.2 U17.9 113.04,72.63 arc(113.02,72.7) 112.98,72.76 112.97,72.78 arc(112.93,72.84) 112.91,72.91 112.91,73.72 arc(112.65,74.36) 112.01,74.62 108.31,74.62 arc(107.71,74.87) 107.47,75.46 107.47,77.46 arc(107.61,78.2) 108.03,78.83 108.26,79.05 arc(109.22,79.45) 110.18,79.05 111.16,78.07 arc(111.4,77.91) 111.69,77.85 111.84,77.85 arc(112.04,77.89) 112.21,78 112.79,78.58 arc(113.12,78.8) 113.51,78.88 J11.6
USB30_TXN: length 10.2
  TOP w0.109: C97.1 118.86,69.98 U15.4 U15.7 118.86,72.63 arc(118.88,72.7) 118.92,72.76 118.93,72.78 arc(118.98,72.84) 118.99,72.91 118.99,74.56 arc(118.98,74.63) 118.93,74.69 118.85,74.78 arc(118.76,74.92) 118.72,75.08 118.72,75.67 arc(118.63,76.13) 118.37,76.53 118.36,76.54 arc(118.12,77.13) 118.36,77.72 118.68,78.03 arc(118.79,78.21) 118.83,78.41 118.83,78.66 arc(118.77,78.82) 118.62,78.88 J11.8
USB30_TXP: length 10.4
  TOP w0.109: C98.1 119.62,70.24 arc(119.43,70.52) 119.36,70.85 U15.5 U15.6 119.36,72.63 arc(119.35,72.7) 119.31,72.76 119.29,72.78 arc(119.25,72.84) 119.24,72.91 119.24,74.56 arc(119.21,74.73) 119.11,74.87 119.03,74.95 arc(118.99,75.01) 118.97,75.08 118.97,75.67 arc(118.86,76.23) 118.54,76.71 118.54,76.71 arc(118.37,77.13) 118.54,77.54 118.85,77.86 arc(119.02,78.11) 119.08,78.41 119.08,78.66 arc(119.15,78.82) 119.3,78.88 J11.9
USB_HUB_1V8: length 47.8
  TOP w0.254: U19.21 118.27,61.62 C127.1 v1(117.14,61.21) ; U19.25 122.47,57.95 v1(121.16,56.64) C123.1 ; C125.1 123.19,56.44 123.34,56.59 v1(123.34,56.64) 123.34,56.92 123.97,57.55 U19.28 ; v1(123.44,64.74) 124.13,65.43 127.56,65.43 128.47,66.34 128.47,68.38 C124.1 127.12,68.2 125.91,68.2 125.47,67.76 U19.6
  BOTTOM w0.381: C126.1 120.39,56.78 119.84,57.33 118.57,57.33 117.78,58.12 117.78,60.57 v1(117.14,61.21) 117.21,61.21 117.78,61.77 117.78,63.37 117.09,64.06 117.09,65.84 118.06,66.8 122.17,66.8 123.44,65.53 v1(123.44,64.74) ; C126.1 120.39,56.01 120.9,55.5 122.81,55.5 123.34,56.03 v1(123.34,56.64) ; C126.1 v1(121.16,56.64)
USB_HUB_3V3: length 55.2
  TOP w0.254: 130.43,62.87 130.18,63.11 U19.43 ; 130.43,62.87 130.18,62.62 U19.42 ; 130.43,62.87 130.93,62.87 C110.1 v1(132.07,63.25) 132.07,64.53 C109.1 130.68,64.65 130.68,64.39 130.41,64.11 U19.45 ; U19.26 122.97,57.44 v1(122.17,56.64) C121.1 ; U19.36 127.97,56.89 v1(128.27,56.59) C118.1 ; U19.20 119.75,62.11 v1(119.71,62.15) 118.94,62.15 C120.1 ; U19.15 119.02,64.62 C116.1 118.86,65.4 v1(118.73,65.53) ; R129.2 v1(130.56,59.06) ; U19.31 v1(125.47,59.67)
  TOP w0.381: R128.2 R127.2 C117.1 131.31,57.02 130.81,57.02 130.56,57.27 v1(130.56,59.06)
  BOTTOM w0.381: v1(125.47,59.67) 125.48,59.66 125.48,58.65 ; v1(118.73,65.53) 118.73,63.14 v1(119.71,62.15) 121.51,60.35 121.51,58.22 122.17,57.56 ; v1(122.17,56.64) 122.17,57.56 ; 122.17,57.56 122.81,58.19 125.02,58.19 125.48,58.65 ; 125.48,58.65 126.11,58.01 126.11,57.2 126.72,56.59 v1(128.27,56.59) 129.64,56.59 130.56,57.51 v1(130.56,59.06) 130.56,60.96 R130.2 130.31,61.88 131.68,63.25 v1(132.07,63.25)
USB_HUB_3V3_OUT: length 26.2
  TOP w0.254: R128.1 v1(130.3,54.15) ; v1(124.83,70.71) C115.1 C114.1 123.97,68.1 U19.9
  ART03 w0.254: v1(124.83,70.71) 124.83,70.11 126.03,68.91 126.03,55.32 128.09,53.26 129.69,53.26 130.3,53.87 v1(130.3,54.15)
USB_HUB_5V0: length 23
  TOP w0.254: U19.8 124.47,67.83 124.99,68.35 125.26,68.35 C113.1 C112.1 v1(125.87,70.71) ; R126.2 v1(129.29,54.15)
  ART03 w0.254: v1(129.29,54.15) 129.26,54.15 127.23,56.18 127.23,69.35 v1(125.87,70.71)
USB_HUB_DM1: length 11.2
  TOP w0.109: U19.18 120.3,63.11 arc(120.23,63.1) 120.17,63.06 120.15,63.04 arc(120.09,63) 120.02,62.99 116.64,62.99 arc(116.24,63.16) 116.07,63.56 116.07,65.53 arc(115.91,66.36) 115.43,67.07 114.94,67.57 arc(114.75,67.85) 114.68,68.19 114.68,68.33 arc(114.73,68.57) 114.86,68.77 R105.2
USB_HUB_DM2: length 8.7
  TOP w0.109: U19.16 120.3,64.11 arc(120.23,64.1) 120.17,64.06 120.15,64.04 arc(120.09,64) 120.02,63.99 117.9,63.99 arc(117.38,64.2) 117.17,64.72 117.17,67.23 arc(117.19,67.33) 117.24,67.41 117.33,67.49 arc(117.43,67.65) 117.47,67.84 117.47,68.33 arc(117.52,68.57) 117.66,68.77 R115.2
USB_HUB_DM3: length 28.7
  TOP w0.109: U19.13 120.3,65.62 arc(120.23,65.6) 120.17,65.56 120.15,65.54 arc(120.09,65.5) 120.02,65.49 119.79,65.49 arc(119.68,65.54) 119.63,65.65 119.63,66.14 arc(119.73,66.38) 119.97,66.48 121.08,66.48 arc(121.51,66.66) 121.69,67.09 121.69,70.22 arc(121.84,70.96) 122.26,71.59 123.25,72.59 arc(123.88,73) 124.62,73.15 128.31,73.15 arc(129.05,73) 129.68,72.59 131.79,70.47 arc(132.31,70.12) 132.91,70 133.37,70 arc(133.63,70.11) 133.74,70.37 133.74,70.6 arc(133.75,70.67) 133.8,70.73 133.81,70.75 arc(133.85,70.81) 133.87,70.88 U18.2 U18.9 133.87,72.63 arc(133.85,72.7) 133.81,72.76 133.8,72.78 arc(133.75,72.84) 133.74,72.91 133.74,73.15 arc(133.75,73.21) 133.78,73.25 133.86,73.34 arc(133.95,73.46) 133.98,73.61 133.98,75.23 arc(134.06,75.42) 134.25,75.5 J12.2
USB_HUB_DM4: length 29.7
  TOP w0.109: J12.8 134.22,77.87 arc(134.04,77.6) 133.98,77.28 133.98,77.14 arc(134.05,76.98) 134.21,76.91 135.74,76.91 arc(136.07,76.77) 136.22,76.43 136.22,75.31 arc(136.09,74.68) 135.73,74.14 135.52,73.93 arc(135.31,73.62) 135.24,73.25 135.24,72.91 arc(135.25,72.84) 135.3,72.78 135.31,72.76 arc(135.35,72.7) 135.37,72.63 U18.6 U18.5 135.37,70.88 arc(135.35,70.81) 135.31,70.75 135.3,70.73 arc(135.25,70.67) 135.24,70.6 135.24,70.19 arc(135.15,69.74) 134.9,69.37 134.39,68.86 arc(132.92,68.25) 131.45,68.86 129.14,71.16 arc(128.51,71.58) 127.77,71.73 124.08,71.73 arc(123.21,71.37) 122.85,70.5 122.85,68.07 arc(122.86,68) 122.9,67.94 122.92,67.92 arc(122.96,67.86) 122.97,67.79 U19.11
USB_HUB_DM5: length 46
  TOP w0.109: U19.32 125.97,57.94 arc(125.99,57.87) 126.03,57.81 126.04,57.79 arc(126.08,57.73) 126.1,57.66 126.1,54.03 arc(125.97,53.4) 125.61,52.87 125.26,52.51 arc(125.05,52.2) 124.98,51.84 124.98,51.73 arc(124.94,51.53) 124.83,51.37 v1(124.67,51.21) ; R184.2 129.98,22.79 arc(130.03,22.86) 130.05,22.94 130.05,22.96 arc(130.03,23.05) 129.98,23.12 D33.1 129.61,23.71 arc(129.64,23.88) 129.74,24.03 129.84,24.12 arc(130,24.36) 130.05,24.64 130.05,24.75 arc(129.99,25.05) 129.83,25.29 129.22,25.9 arc(128.75,26.61) 128.58,27.45 128.58,32.24 arc(128.89,32.98) 129.64,33.29 130.74,33.29 arc(131.49,33.61) 131.8,34.36 131.8,34.66 arc(131.65,35.4) 131.23,36.03 arc(130.87,36.9) 131.23,37.76 131.4,37.93 arc(131.87,39.07) 131.4,40.21 130.27,41.34 arc(129.64,41.75) 128.9,41.9 126.7,41.9 arc(126.51,41.86) 126.35,41.76 v1(126.18,41.6)
  BOTTOM w0.109: v1(126.18,41.6) 126.02,41.76 arc(125.86,41.86) 125.67,41.9 125.49,41.9 arc(125.13,42.05) 124.98,42.41 124.98,50.7 arc(124.94,50.89) 124.83,51.05 v1(124.67,51.21)
USB_HUB_DM6: length 32.4
  TOP w0.109: U19.34 126.97,57.94 arc(126.99,57.87) 127.03,57.81 127.04,57.79 arc(127.08,57.73) 127.1,57.66 127.1,51.37 arc(126.87,50.82) 126.31,50.59 119.09,50.59 arc(119.01,50.62) 118.97,50.7 v1(118.97,50.94) ; v1(119.25,39.01) 119.25,38.87 arc(119.29,38.77) 119.39,38.73 119.89,38.73 arc(120.13,38.78) 120.33,38.92 R143.1
  BOTTOM w0.109: v1(119.25,39.01) 119.03,38.8 arc(118.93,38.73) 118.81,38.71 118.66,38.71 arc(118.51,38.74) 118.38,38.82 118.31,38.89 arc(118.22,39.03) 118.19,39.19 118.19,45.92 arc(118.37,46.84) 118.89,47.62 119.54,48.26 arc(119.95,48.88) 120.09,49.6 120.09,50.03 arc(119.94,50.41) 119.56,50.56 119.11,50.56 arc(119.01,50.6) 118.97,50.7 v1(118.97,50.94)
USB_HUB_DP1: length 11.6
  TOP w0.109: U19.19 120.3,62.62 arc(120.23,62.63) 120.17,62.67 120.15,62.69 arc(120.09,62.73) 120.02,62.74 116.64,62.74 arc(116.06,62.98) 115.82,63.56 115.82,65.53 arc(115.68,66.27) 115.26,66.9 114.76,67.39 arc(114.52,67.76) 114.43,68.19 114.43,68.33 arc(114.38,68.57) 114.25,68.77 R106.2
USB_HUB_DP2: length 9.1
  TOP w0.109: R116.2 117.04,68.77 arc(117.18,68.57) 117.22,68.33 117.22,67.84 arc(117.2,67.75) 117.15,67.67 117.07,67.59 arc(116.96,67.42) 116.92,67.23 116.92,64.72 arc(117.21,64.03) 117.9,63.74 120.02,63.74 arc(120.09,63.73) 120.15,63.69 120.17,63.67 arc(120.23,63.63) 120.3,63.62 U19.17
USB_HUB_DP3: length 28.6
  TOP w0.109: U19.14 120.3,65.11 arc(120.23,65.13) 120.17,65.17 120.15,65.19 arc(120.09,65.23) 120.02,65.24 119.79,65.24 arc(119.5,65.36) 119.38,65.65 119.38,66.14 arc(119.55,66.55) 119.97,66.73 121.08,66.73 arc(121.34,66.83) 121.44,67.09 121.44,70.22 arc(121.61,71.06) 122.08,71.76 123.08,72.76 arc(123.79,73.23) 124.62,73.4 128.31,73.4 arc(129.14,73.23) 129.85,72.76 131.97,70.64 arc(132.4,70.35) 132.91,70.25 133.37,70.25 arc(133.46,70.29) 133.49,70.37 133.49,70.6 arc(133.48,70.67) 133.44,70.73 133.42,70.75 arc(133.38,70.81) 133.37,70.88 U18.1 U18.10 133.37,72.63 arc(133.38,72.7) 133.42,72.76 133.44,72.78 arc(133.48,72.84) 133.49,72.91 133.49,73.15 arc(133.52,73.3) 133.61,73.43 133.69,73.51 arc(133.72,73.56) 133.73,73.61 133.73,74.1 arc(133.63,74.58) 133.36,75 J12.3
USB_HUB_DP4: length 29.7
  TOP w0.109: U19.12 122.47,67.79 arc(122.49,67.86) 122.53,67.92 122.54,67.94 arc(122.58,68) 122.6,68.07 122.6,70.5 arc(123.03,71.55) 124.08,71.98 127.77,71.98 arc(128.61,71.81) 129.32,71.34 131.62,69.03 arc(132.92,68.5) 134.21,69.03 134.73,69.55 arc(134.92,69.84) 134.99,70.19 134.99,70.6 arc(134.98,70.67) 134.94,70.73 134.92,70.75 arc(134.88,70.81) 134.87,70.88 U18.4 U18.7 134.87,72.63 arc(134.88,72.7) 134.92,72.76 134.94,72.78 arc(134.98,72.84) 134.99,72.91 134.99,73.25 arc(135.08,73.71) 135.34,74.11 135.56,74.32 arc(135.86,74.77) 135.97,75.31 135.97,76.43 arc(135.9,76.59) 135.74,76.66 134.21,76.66 arc(133.87,76.8) 133.73,77.14 133.73,77.16 arc(133.64,77.59) 133.4,77.96 J12.9
USB_HUB_DP5: length 46
  TOP w0.109: v1(125.53,51.21) 125.37,51.37 arc(125.27,51.53) 125.23,51.73 125.23,51.84 arc(125.28,52.11) 125.43,52.34 125.79,52.69 arc(126.2,53.31) 126.35,54.03 126.35,57.66 arc(126.36,57.73) 126.4,57.79 126.42,57.81 arc(126.46,57.87) 126.47,57.94 U19.33 ; R185.2 130.36,22.8 arc(130.31,22.86) 130.3,22.94 130.3,22.96 arc(130.31,23.04) 130.36,23.11 D32.1 130.74,23.71 arc(130.71,23.88) 130.61,24.03 130.51,24.12 arc(130.35,24.36) 130.3,24.64 130.3,24.76 arc(130.22,25.14) 130,25.47 129.4,26.08 arc(128.98,26.71) 128.83,27.45 128.83,32.24 arc(129.07,32.81) 129.64,33.05 130.74,33.05 arc(131.67,33.43) 132.05,34.36 132.05,34.66 arc(131.88,35.5) 131.41,36.2 arc(131.12,36.9) 131.41,37.59 131.58,37.75 arc(132.12,39.07) 131.58,40.38 130.45,41.51 arc(129.74,41.98) 128.9,42.15 126.7,42.15 arc(126.51,42.19) 126.35,42.3 v1(126.18,42.46)
  BOTTOM w0.109: v1(126.18,42.46) 126.02,42.3 arc(125.86,42.19) 125.67,42.15 125.49,42.15 arc(125.3,42.23) 125.23,42.41 125.23,50.7 arc(125.27,50.89) 125.37,51.05 v1(125.53,51.21)
USB_HUB_DP6: length 32.4
  TOP w0.109: R138.1 120.33,38.3 arc(120.13,38.44) 119.89,38.48 119.39,38.48 arc(119.29,38.44) 119.25,38.34 v1(119.25,38.15) ; U19.35 127.47,57.94 arc(127.46,57.87) 127.42,57.81 127.4,57.79 arc(127.36,57.73) 127.35,57.66 127.35,51.37 arc(127.04,50.64) 126.31,50.34 119.4,50.34 arc(119.24,50.31) 119.11,50.22 v1(118.97,50.08)
  BOTTOM w0.109: v1(119.25,38.15) 119.09,38.31 arc(118.93,38.42) 118.73,38.46 118.66,38.46 arc(118.41,38.51) 118.2,38.65 118.13,38.72 arc(117.99,38.93) 117.94,39.19 117.94,45.92 arc(118.14,46.93) 118.71,47.79 119.36,48.44 arc(119.72,48.97) 119.84,49.6 119.84,50.03 arc(119.76,50.23) 119.56,50.31 119.36,50.31 arc(119.22,50.28) 119.1,50.2 v1(118.97,50.08)
WIFI_PWR_EN: length 69.2
  TOP w0.152: CN4.79 67.92,20.83 70.79,23.7 102.84,23.7 103.71,24.56 108.89,24.56 110.36,26.04 110.36,29.21 113.67,32.52 113.67,42.82 R155.1
N16958730: length 12.9
  TOP w0.508: J1.1 10.73,88.14 18.1,88.14 J1.5 19.38,86.86 L2.1
N16959452: length 2.5
  TOP w0.254: v1(14.69,64.72) 14.74,64.77 U1.5
  BOTTOM w0.254: R3.2 14.74,64.77 v1(14.69,64.72)
N16959584: length 7.6
  TOP w0.254: U1.4 v1(14.69,65.72)
  BOTTOM w0.254: v1(14.69,65.72) 14.17,65.72 13.89,65.44 13.89,64.25 14.39,63.75 R2.1 R1.1 C2.1
N16961195: length 8.7
  TOP w0.254: U2.4 v1(9.1,65.72)
  BOTTOM w0.254: v1(9.1,65.72) 8.62,65.72 8.26,65.35 8.26,63.09 8.61,62.74 R7.1 R6.1 C11.1
N16961300: length 3.5
  TOP w0.254: U2.5 9.15,64.77 v1(9.1,64.72)
  BOTTOM w0.254: R8.1 10.68,64.77 R9.1 10.61,64.72 v1(9.1,64.72)
N16963036: length 2.2
  TOP w0.152: LED1.2 v1(135.16,1.56)
  BOTTOM w0.152: R4.2 135.25,1.65 v1(135.16,1.56)
N16963423: length 1.9
  TOP w0.152: LED2.2 v1(138.94,1.56)
  BOTTOM w0.152: v1(138.94,1.56) 139.03,1.65 R12.2
N16965184: length 5.6
  BOTTOM w0.102: R17.2 130.29,14.73 131.9,14.73 D8.2 132.43,15.21 J4.1
N16965201: length 5.6
  BOTTOM w0.102: J4.2 132.46,16.31 D7.2 131.9,15.75 130.29,15.75 R18.2
N16965205: length 5.7
  BOTTOM w0.102: J4.3 132.54,17.41 D6.2 131.9,16.76 130.29,16.76 R19.2
N16965209: length 5.7
  BOTTOM w0.102: J4.5 132.61,19.61 D5.2 131.87,19.28 130.89,19.28 130.35,19.81 R20.2
N16965213: length 5.8
  BOTTOM w0.102: J4.7 134.08,21.81 133.6,21.34 D4.2 131.9,20.83 130.29,20.83 R23.2
N16965217: length 5.8
  BOTTOM w0.102: J4.8 133.91,22.91 133.73,22.73 D3.2 132.36,22.73 131.72,22.1 130.42,22.1 R24.2
N16965221: length 5.7
  BOTTOM w0.152: R25.2 130.29,23.62 131.9,23.62 D2.2 132.52,24.01 J4.9
N16966392: length 2.3
  TOP w0.152: R26.2 139.48,7.4 U4.3
N16966399: length 4.5
  TOP w0.381: R22.2 C22.1 C23.1 138.56,7.01 138.21,6.66 U4.2
N16970771: length 2.5
  TOP w0.102: R39.2 59.91,59.39 U7.23
N16970773: length 2.3
  TOP w0.102: U7.24 60.31,58.78 R36.2
N16970775: length 2.1
  TOP w0.102: U7.25 60.71,58.41 R37.2
N16970777: length 2.4
  TOP w0.102: U7.26 61.11,59.02 R42.2
N16970779: length 2.9
  TOP w0.102: U7.27 61.51,59.14 61.82,58.83 62.32,58.83 R41.2
N16970781: length 3.1
  TOP w0.102: R40.2 57.83,58.28 58.47,58.93 58.93,58.93 59.51,59.51 U7.22
N16970797: length 5
  TOP w0.102: U7.35 66.19,62.66 66.45,62.41 66.45,61.4 R49.2
N16970858: length 7.9
  TOP w0.152: Y2.3 69.79,63.59 69.62,63.75 67.27,63.75 C42.1 66.67,63.83 65.61,63.83 64.84,63.06 U7.36
N16970862: length 6.4
  TOP w0.152: Y2.1 68.29,64.27 68.07,64.06 67.49,64.06 67.02,64.52 C41.1 66.62,64.14 65.48,64.14 64.81,63.46 U7.37
N16970890: length 8.6
  TOP w0.152: U7.12 56.93,64.27 v1(55.9,65.29)
  BOTTOM w0.152: D59.2 55.63,66.54 C45.1 55.9,65.81 v1(55.9,65.29) 56.12,65.29 57.41,64 R158.2 R53.2
N16971097: length 5.3
  TOP w0.152: v1(65.84,65.27) 65.32,64.75 64.5,64.75 64.01,64.26 U7.39
  BOTTOM w0.152: R38.1 64.63,64.77 65.34,64.77 v1(65.84,65.27)
N16971238: length 3.6
  BOTTOM w0.508: J6.1 71.46,72.21 C43.1
N16971261: length 96.5
  TOP w1.016: J6.15 69.33,78.69 55.11,78.69 J6.16
  GND02 w1.016: J6.15 69.33,78.69 55.11,78.69 J6.16
  ART03 w1.016: J6.16 55.11,78.69 69.33,78.69 J6.15
  ART04 w1.016: J6.16 55.11,78.69 69.33,78.69 J6.15
  PWR05 w1.016: J6.16 55.11,78.69 69.33,78.69 J6.15
  BOTTOM w1.016: J6.15 69.33,78.69 63.94,78.69 R55.1 63.5,79.12 C44.1 60.91,78.69 55.11,78.69 J6.16
N16971318: length 8.8
  BOTTOM w0.152: J6.12 67.43,87.13 70.5,87.13 72.14,85.5 R50.1
N16971320: length 15.3
  BOTTOM w0.152: R51.1 70.87,87.76 66.24,87.76 64.49,86 J6.13
N16971466: length 4.5
  TOP w0.152: U7.32 64.11,61.46 64.47,61.11 66.07,61.11 66.37,60.81 66.37,60.46 R52.1
N16971541: length 2.8
  TOP w0.152: v1(64.85,60.58) 64.44,60.58 63.95,61.06 U7.31
  BOTTOM w0.152: R46.2 64.47,60.95 v1(64.85,60.58)
N16976499: length 2.4
  TOP w0.102: R68.2 79.52,59.03 U8.26
N16976501: length 2.1
  TOP w0.102: R60.2 79.12,58.41 U8.25
N16976503: length 2.3
  TOP w0.102: R61.2 78.72,58.77 U8.24
N16976505: length 2.5
  TOP w0.102: U8.23 78.32,59.39 R63.2
N16976507: length 3.1
  TOP w0.102: R64.2 76.27,58.28 76.83,58.85 77.24,58.85 77.92,59.53 U8.22
N16976509: length 2.9
  TOP w0.102: R67.2 80.74,58.83 80.24,58.83 79.92,59.14 U8.27
N16976515: length 4.8
  TOP w0.102: U8.35 84.4,62.66 84.76,62.31 84.76,61.5 R73.2
N16976541: length 6.4
  TOP w0.152: U8.37 83.71,63.46 84.35,64.11 85,64.11 C57.1 85.42,64.47 85.83,64.06 86.55,64.06 86.7,64.21 Y3.1
N16976545: length 7.8
  TOP w0.152: Y3.3 88.2,63.57 88.02,63.75 85.68,63.75 C58.1 85.1,63.8 84.48,63.8 83.74,63.06 U8.36
N16976569: length 8.8
  TOP w0.152: U8.12 75.34,64.27 v1(74.31,65.29)
  BOTTOM w0.152: D60.2 73.91,66.67 C61.1 74.31,65.81 v1(74.31,65.29) 74.61,65.29 75.9,64 R159.2 R77.2
N16976627: length 6
  TOP w0.152: v1(84.25,65.27) 83.73,64.75 82.96,64.75 82.48,64.26 U8.39
  BOTTOM w0.152: v1(84.25,65.27) 84.25,64.31 83.73,63.79 82.58,63.79 R62.1
N16976697: length 4.5
  TOP w0.152: R76.1 84.86,60.38 84.86,60.73 84.51,61.09 82.8,61.09 82.43,61.46 U8.32
N16976807: length 3.6
  BOTTOM w0.508: J7.1 91.5,72.21 C59.1
N16976813: length 96.5
  TOP w1.016: J7.16 75.15,78.69 89.37,78.69 J7.15
  GND02 w1.016: J7.16 75.15,78.69 89.37,78.69 J7.15
  ART03 w1.016: J7.15 89.37,78.69 75.15,78.69 J7.16
  ART04 w1.016: J7.15 89.37,78.69 75.15,78.69 J7.16
  PWR05 w1.016: J7.15 89.37,78.69 75.15,78.69 J7.16
  BOTTOM w1.016: J7.15 89.37,78.69 84,78.69 R78.1 83.57,79.12 C60.1 81.1,78.69 75.15,78.69 J7.16
N16976831: length 15.5
  BOTTOM w0.152: J7.13 80.49,83.68 R75.1
N16976833: length 7.6
  BOTTOM w0.152: R74.1 90.97,84.76 87.58,84.76 J7.12
N16976861: length 2.6
  TOP w0.152: U8.31 82.32,61.06 82.8,60.58 v1(83.26,60.58)
  BOTTOM w0.152: v1(83.26,60.58) 83.01,60.82 R70.2
N16985416: length 21.6
  TOP w0.508: J10.2 33.62,88.3 34.42,87.5 L11.1
  ART03 w0.508: J10.2 J10.1
  BOTTOM w0.508: J10.4 J10.3 24.54,89.23 31.32,89.23 J10.2
N16990092: length 1.3
  BOTTOM w0.152: U12.3 28.21,79.74 R120.1
N16998300: length 3.5
  BOTTOM w0.152: Q10.2 85.41,63.43 R150.2 R152.2
N17003573: length 27
  TOP w0.152: Q21.1 91.36,56.82 89.61,56.82 Q19.1 88.84,55.32 R165.1 89.85,54.31 92.03,54.31 R164.2 93.15,54.31 104.42,54.31 105.09,54.98 Q20.1 104.34,56.79 102.67,56.79 Q18.1
N17013167: length 5.1
  TOP w0.152: R142.2 98.62,55.32 Q8.1 97.89,56.77 96.65,56.77 96.39,57.02 Q9.3
N17014356: length 9.2
  TOP w0.152: R149.1 97.28,59.87 96.82,59.41 95.75,59.41 95.44,59.11 Q9.1 95.44,55.32 R151.1
N17029455: length 13.1
  BOTTOM w0.152: R153.2 114.59,16.99 115.44,16.99 115.64,17.19 U24.4 115.64,18.79 115.9,19.05 122.02,19.05 122.24,18.83 U25.4 122.24,17.29 121.92,16.97 121.22,16.97 C148.1
N17029502: length 2.4
  BOTTOM w0.152: R154.1 114.64,16.59 115.44,16.59 115.64,16.39 U24.3
N17029521: length 2.3
  BOTTOM w0.152: R161.1 121.17,16.51 122,16.51 122.24,16.27 U25.3
N17036087: length 5
  BOTTOM w0.152: J19.2 133.88,36.63 133.16,37.35 U27.6 132.63,36.37 C169.1 R173.2
N17036090: length 7.1
  BOTTOM w0.102: J19.3 133.96,39.17 133.14,38.35 U27.4 132.63,39.45 C168.1 131.89,40.18 130.34,40.18 R174.2
N17036093: length 8.2
  BOTTOM w0.152: R175.2 R171.2 129.79,38.35 C167.1 130.25,38.35 130.68,38.79 131.72,38.79 131.9,38.61 131.9,38.05 132.11,37.85 U27.5 133.45,37.85 133.51,37.9 J19.7
N17043533: length 4.7
  BOTTOM w0.254: R172.1 C164.1 R176.1 111,27.05 110,26.05 U26.4
N17043616: length 3.5
  BOTTOM w0.254: U26.5 110.95,26.25 R178.1 R177.2
N17043933: length 3.4
  TOP w0.152: v1(112.39,9.4) 112.59,9.59 J20.1
  BOTTOM w0.152: R180.2 R179.2 112.4,9.39 v1(112.39,9.4)
N17044212: length 3
  TOP w0.102: J20.7 v1(114.99,9.45)
  BOTTOM w0.102: v1(114.99,9.45) 114.99,9.98 114.6,10.36 R181.2
N17046085: length 2.6
  TOP w0.109: J20.38 130.59,20.08 arc(130.55,20.25) 130.46,20.39 130.44,20.41 arc(130.35,20.55) 130.31,20.72 130.31,20.85 arc(130.36,21.08) 130.49,21.28 R185.1
N17046088: length 2.6
  TOP w0.109: J20.36 129.79,20.08 arc(129.82,20.25) 129.92,20.39 129.93,20.41 arc(130.03,20.55) 130.06,20.72 130.06,20.82 arc(130.02,21.06) 129.88,21.26 R184.1
N17046548: length 2.5
  TOP w0.152: R182.1 123.39,21.15 J20.20
N17046561: length 2.4
  TOP w0.152: R183.1 124.19,21.36 J20.22
N17063858: length 8
  TOP w0.203: U9.17 50.69,62.41 50.9,62.2 50.66,61.97 U9.16
  TOP w0.254: C69.1 C66.1 C67.1 C68.1 ; C69.1 51.57,61.84 51.21,62.2 50.9,62.2 ; C69.1 C68.1 ; C68.1 L8.2
N17063899: length 11.3
  TOP w0.203: C73.1 44.75,63.37 44.93,63.55 45.34,63.55 ; U9.2 45.55,63.76 45.34,63.55 ; 45.34,63.55 45.57,63.32 U9.3
  TOP w0.254: L9.2 44.74,67.95 v1(43.74,68.95) ; C73.1 C72.1 44.31,64.73 v1(43.64,65.41)
  BOTTOM w0.254: v1(43.74,68.95) 43.74,68.43 44.2,67.97 44.2,67.26 43.64,66.7 v1(43.64,65.41)
N17064255: length 3.5
  TOP w0.203: C71.1 47.8,67.65 47.8,66.63 48.58,65.85 U9.24
N17064258: length 3.6
  TOP w0.203: C74.1 48.16,67.6 48.16,66.78 49.03,65.9 U9.23
N17064495: length 3.6
  TOP w0.203: C75.1 50.37,67.62 50.37,66.93 49.48,66.04 U9.22
N17064497: length 4.3
  TOP w0.203: C76.1 50.72,67.62 50.72,66.78 49.86,65.92 49.86,65.38 50.13,65.11 U9.21
N17064707: length 3.2
  TOP w0.203: U9.20 50.63,63.76 50.88,64.01 50.88,64.84 C78.1
N17064710: length 2.8
  TOP w0.203: U9.19 50.89,63.32 51.26,63.68 51.26,64.2 C79.1
N17064713: length 2.7
  TOP w0.203: v1(46.85,59.69) 47.09,59.69 47.68,60.28 U9.10
  BOTTOM w0.254: v1(46.85,59.69) 46.48,60.06 C80.1
N17064960: length 3.6
  TOP w0.152: R91.2 46.48,66.9 47.68,65.7 U9.26
N17065329: length 2
  BOTTOM w0.203: R99.1 C85.1 R97.1
N17072089: length 19.5
  TOP w0.203: J8.1 44.6,86.06 44.6,77.44 v1(45.72,76.33) 46.47,75.57 D14.2 R84.2 C65.1 47.5,72.38 R81.1
  BOTTOM w0.203: R83.1 45.72,76.21 v1(45.72,76.33)
N17072509: length 2
  TOP w0.203: R84.1 45.47,71.37 C70.1 R82.1
N17073944: length 11.5
  TOP w0.203: R92.1 47.51,76.57 46.99,77.09 46.99,83.05 J8.2
N17074279: length 16.5
  TOP w0.203: J8.6 50.44,86.09 51.59,84.94 51.59,73.95 D15.2 C83.1 51.05,71.37 R88.1 R87.2
N17074336: length 9.1
  BOTTOM w0.203: J8.3 47.74,79.49 D17.2 R243.1 48.2,73.97 Q5.2
N17074726: length 8.1
  BOTTOM w0.203: Q4.2 51.37,73.97 R242.1 D16.2 50.92,80.52 J8.4
N17074747: length 2.5
  BOTTOM w0.203: Q4.3 50.42,70.48 R90.1 R89.1
N17075125: length 1.7
  BOTTOM w0.203: R89.2 50.42,68.46 C81.1
N17075408: length 2.5
  BOTTOM w0.203: R93.1 R94.1 47.24,70.48 Q5.3
N17075443: length 1.7
  BOTTOM w0.203: R93.2 47.24,68.46 C82.1
N17075521: length 6.5
  BOTTOM w0.152: Q4.1 48.74,72.52 47.02,72.52 Q5.1 45.31,72.26 C84.1 R95.1
N17112236: length 4.6
  BOTTOM w0.152: U5.2 26.74,52 26.29,52.45 25.61,52.45 C29.1 25.2,52.84 24.87,52.5 24.32,52.5 Y1.2
N17112246: length 4.8
  BOTTOM w0.152: Y1.1 24.37,52.2 24.83,52.2 C28.1 25.56,52.15 26.09,52.15 26.88,51.35 U5.1
N17112592: length 5.7
  BOTTOM w0.152: R29.1 R28.2 31.88,48.9 31.88,50.55 31.6,50.83 30.99,50.83 30.78,51.03 30.78,51.8 30.99,52 U5.7
N17115633: length 2.8
  BOTTOM w0.152: Q3.3 22.47,48.39 R241.2 21.24,48.89 Q12.1
N17117541: length 2.2
  BOTTOM w0.152: U12.4 29.91,78.8 29.72,78.99 29.72,79.75 R118.2
N17135429: length 2.3
  BOTTOM w0.152: R5.1 49.51,13.31 50.27,13.31 50.49,13.09 U3.3
N17149641: length 2.7
  BOTTOM w0.152: U13.4 113.53,88.24 R121.2
N17149662: length 3.7
  BOTTOM w0.152: U13.3 115.13,85.03 114.91,84.81 114,84.81 113.79,85.01 R125.1
N17150434: length 28.6
  TOP w0.762: J11.22 J11.19
  BOTTOM w0.762: J11.20 J11.19 109.39,86.45 L10.1 ; J11.22 J11.21
N17156781: length 1.9
  TOP w0.254: U19.27 v1(123.47,59.67)
  BOTTOM w0.254: v1(123.47,59.67) 123.44,59.69 R133.1
N17157129: length 9.4
  TOP w0.152: U19.22 120.3,61.11 120.19,61.01 119.36,61.01 118.8,60.45 118.8,59.23 118.24,58.67 118.24,58.17 C131.1 118.24,57.4 118.24,55.18 117.93,54.88 Y4.3
N17157136: length 7.4
  TOP w0.152: U19.23 120.28,60.62 120.19,60.71 119.48,60.71 119.11,60.34 119.11,59.12 118.54,58.55 118.54,58.12 C130.1 118.54,57.45 118.54,56.57 118.73,56.38 Y4.1
N17158781: length 3.7
  TOP w0.254: U19.41 130.43,62.11 C122.1 v1(132.07,61.22)
  BOTTOM w0.254: v1(132.07,61.22) 132.06,61.21 R130.1
N17159812: length 2.8
  TOP w0.254: R129.1 130.73,60.65 130.73,61.16 130.28,61.62 U19.40
N17161099: length 2.9
  TOP w0.109: U19.30 124.97,57.94 arc(124.96,57.87) 124.92,57.81 124.9,57.79 arc(124.86,57.73) 124.85,57.66 124.85,56.5 arc(124.89,56.27) 125.03,56.07 R131.2
N17161102: length 2.9
  TOP w0.109: R132.2 124.41,56.07 arc(124.55,56.28) 124.6,56.53 124.6,57.66 arc(124.58,57.73) 124.54,57.79 124.53,57.81 arc(124.49,57.87) 124.47,57.94 U19.29
N17163205: length 30
  TOP w0.762: J12.11 J12.12
  BOTTOM w0.762: J12.12 J12.6 ; J12.5 J12.11 127.13,81.48 L12.1
N17166688: length 3.7
  BOTTOM w0.152: U20.4 129.91,88.24 C132.1 R134.2
N17166697: length 3.6
  BOTTOM w0.152: R135.1 130.18,85.12 130.45,84.84 131.29,84.84 131.51,85.05 U20.3
N17204481: length 7.9
  TOP w0.152: J21.2 3.73,71.83 3.73,70.27 D34.2 R187.1
N17204515: length 4.3
  TOP w0.152: J21.1 2.29,77.73 D35.2 R186.1
N17208013: length 3
  TOP w0.508: R11.1 46.77,58.08 Q1.3
N17208331: length 11.6
  TOP w0.508: J2.1 39.61,59.85 41.71,57.76 43.61,57.76 D1.1 43.81,56.52 44.32,56.01 45.21,56.01 45.97,55.24
N17208813: length 7.9
  TOP w0.152: Q2.3 51.9,58.08 51.77,58.22 50.37,58.22 49.91,57.76 49.91,57.2 49.61,56.9 48.54,56.9 Q1.1 47.69,55.32 R10.2
N17208925: length 2.8
  TOP w0.152: R13.2 52.01,55.32 Q2.1 51.41,56.05 R14.1
N17240897: length 14
  BOTTOM w0.152: Q17.3 91.05,7.84 90.78,8.1 90.78,8.61 90.04,9.35 R192.2 C180.2 89.03,10.26 88.65,10.64 86.69,10.64 Q15.1 85.17,10.62 81.84,10.62 Q16.1
N17241015: length 4
  BOTTOM w0.635: Q15.2 86.89,8.94 85.18,8.94 R191.1
N17241660: length 5.5
  BOTTOM w0.152: Q17.1 91.86,9.87 92.61,10.62 94.06,10.62 94.39,10.29 94.39,9.42 R194.1 R193.2
N17241919: length 9.2
  BOTTOM w0.152: R195.2 61.89,9.47 62.93,9.47 C184.1 64.02,10.56 67.85,10.56 68.57,9.84 U31.4
N17241951: length 1.5
  BOTTOM w0.152: U31.3 65.84,9.84 R196.1
N17242291: length 3.4
  BOTTOM w0.152: U32.4 75.26,9.84 C188.1 76.08,7.75 R200.2
N17242323: length 4.7
  BOTTOM w0.152: R197.1 75.65,10.46 73.06,10.46 72.43,9.84 U32.3
N17257942: length 2.3
  BOTTOM w0.152: R199.2 49.39,13.74 50.16,13.74 50.49,14.06 U3.4
N17272255: length 5.3
  TOP w0.381: L15.1 C191.1 14.17,29.33 14.48,29.64 14.48,31.61 U33.16
N17272410: length 2.7
  TOP w0.152: U33.3 17.02,23.76 C192.1
N17272413: length 3.4
  TOP w0.152: C192.2 15.21,23.5 14.48,24.23 U33.1
N17272453: length 2.6
  TOP w0.152: C193.2 18.28,23.61 U33.4
N17272456: length 2.7
  TOP w0.152: U33.5 19.56,23.89 C193.1
N17272490: length 2.6
  TOP w0.152: U33.6 20.82,23.74 C194.1
N17272493: length 4.6
  TOP w0.152: U33.2 15.74,27.23 15.42,27.56 13.34,27.56 C195.1
N17276502: length 16.9
  BOTTOM w0.152: R207.2 105.75,7.71 D29.2 103.31,5.99 97.26,5.99 96.19,4.93 92.56,4.93 91.72,4.09 J30.2
N17276503: length 15.9
  BOTTOM w0.152: R208.2 102.96,7.71 D28.2 101.02,6.5 97,6.5 95.96,5.46 92.33,5.46 91.44,4.57 90.58,4.57 J30.3
N17276504: length 15.1
  BOTTOM w0.152: R209.2 100.16,7.71 D27.2 98.71,6.99 96.7,6.99 95.71,5.99 92.1,5.99 91.26,5.16 89.17,5.16 J30.4
N17276505: length 14.3
  BOTTOM w0.152: J30.5 87.78,5.77 91.06,5.77 91.8,6.5 95.43,6.5 D26.2 97.37,7.71 R210.2
N17284003: length 1.2
  BOTTOM w0.203: R213.2 37.13,14.85 D41.1
N17284390: length 1.2
  BOTTOM w0.203: D42.1 30.65,14.85 R215.2
N17313600: length 3.5
  TOP w0.381: U38.6 25.65,68.77 C204.1
  vias: v1(24.53,69.65) v1(25.53,69.65)
N17313897: length 2
  TOP w0.203: U38.4 R96.2
N17313900: length 2
  TOP w0.152: U38.3 R98.2
N17314015: length 1.4
  TOP w0.152: R98.1 C87.2
N17314022: length 1.4
  TOP w0.203: R96.1 C86.2
N17314158: length 4.9
  TOP w0.152: R102.2 23.75,56.51 23.75,57.65 R100.1 U38.1
N17314600: length 2
  TOP w0.152: U38.2 C88.1
N17314610: length 3.7
  TOP w0.254: U38.5 L18.1
N17314613: length 3.7
  TOP w0.254: U38.8 L19.1
N17315365: length 3.5
  TOP w0.381: U10.6 31.5,68.77 C210.1
  vias: v1(30.37,69.65) v1(31.37,69.65)
N17315397: length 2
  TOP w0.152: U10.3 R224.2
N17315399: length 2
  TOP w0.203: U10.4 R223.2
N17315425: length 1.4
  TOP w0.152: R224.1 C212.2
N17315432: length 1.4
  TOP w0.203: R223.1 C211.2
N17315446: length 4.8
  TOP w0.152: R225.2 29.49,56.41 29.49,57.75 R226.1 U10.1
N17315502: length 2
  TOP w0.152: U10.2 C215.1
N17315506: length 3.7
  TOP w0.254: U10.8 L21.1
N17315508: length 3.7
  TOP w0.254: U10.5 L20.1
N17318769: length 39
  ART03 w0.508: J33.G3 J33.G4 102.34,85.57 101.73,86.18 96.57,86.18 95.84,85.45 J33.G2 J33.G1
  BOTTOM w0.508: J33.G4 102.34,86.47 L27.2
N17319613: length 12
  TOP w0.152: Q21.3 93.09,60.78 94.24,61.93 v1(94.24,63.19) R234.2 ; R233.2 97.79,64.52 v1(98.04,64.26)
  BOTTOM w0.152: v1(94.24,63.19) 94.68,63.63 97.41,63.63 v1(98.04,64.26)
N17319615: length 12.4
  TOP w0.152: v1(104.29,63.2) 104.28,63.21 R231.2 ; Q20.3 107.15,58.08 107.8,58.72 107.8,62.7 v1(107.31,63.19) R232.2
  BOTTOM w0.152: v1(107.31,63.19) 107.3,63.2 v1(104.29,63.2)
N17319817: length 11
  TOP w0.152: Q19.3 89.79,62.8 v1(90.18,63.19) R230.2 ; R229.2 v1(93.21,63.19)
  BOTTOM w0.152: v1(90.18,63.19) v1(93.21,63.19)
N17319825: length 11.8
  TOP w0.152: R228.2 v1(103.24,63.19) 103.81,62.62 103.81,58.38 103.5,58.08 Q18.3 ; R227.2 v1(100.21,63.19)
  BOTTOM w0.152: v1(100.21,63.19) v1(103.24,63.19)
N17366542: length 4.9
  TOP w0.508: C140.1 141.73,35.85 C136.1 U22.2
N17366552: length 2.7
  TOP w0.508: CN1.1 145.39,35.85 C137.1 143.88,35.84 C140.2
N17367118: length 4.4
  TOP w0.109: R138.2 121.73,38.3 arc(121.93,38.44) 122.17,38.48 124.03,38.48 arc(124.19,38.42) 124.26,38.26 U22.6
