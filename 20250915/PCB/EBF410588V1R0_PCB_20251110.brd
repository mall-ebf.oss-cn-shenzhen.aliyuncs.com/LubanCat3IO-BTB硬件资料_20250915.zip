# Allegro board EBF410588V1R0_PCB_20251110.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBUS5V0_TYPEC: length 36.8
  TOP w0.254: v1(26.56,81.61) J10.A9 ; v1(29.16,81.64) 29.06,81.73 J10.A4 ; J10.B4 26.8,85.96 v1(26.36,86.39) ; J10.B9 29.3,85.89 v1(29.8,86.39)
  TOP w0.305: v1(41.12,66.5) 42.88,68.25 42.88,69.14 42.24,69.77 42.24,83.64 v1(41.25,84.63)
  TOP w0.381: v1(26.57,80.75) 26.56,80.75 v1(26.56,81.61) ; v1(29.16,81.64) v1(29.74,81.05) ; v1(29.8,86.39) v1(29.8,87.39) ; v1(26.36,86.39) v1(26.36,87.39)
  BOTTOM w0.254: v1(41.12,66.5) 40.97,66.34 U11.2
  BOTTOM w0.508: 26.64,81.54 26.74,81.43 28.96,81.43 v1(29.16,81.64) v1(29.74,81.05) ; 26.64,81.54 26.64,80.82 v1(26.57,80.75) 26.57,80.47 26.79,80.25 C103.1 ; 26.64,81.54 v1(26.56,81.61)
VCC3V3_RTC_S5: length 24
  BOTTOM w0.254: U6.2 32.87,44.15 24.18,44.15 21.97,46.35 R241.1
  BOTTOM w0.381: D9.2 38.02,49.5 38.02,48.44 37.47,47.89 C31.1 36.89,47.43 U6.2
VCC5V0_SYS_S5: length 203.9
  ART04 w0.254: v1(137.53,2.4) 136.91,1.78 136.22,1.78 135.46,1.02 119.1,1.02 118.8,1.32 8.66,1.32 8.15,1.83 8.15,8.13 7.65,8.64 3.35,8.64 2.82,9.17 2.82,45.87 2.46,46.23 2.46,49.22 3.35,50.11 v1(3.38,50.11)
  BOTTOM w0.254: R198.2 60.05,39.66 v1(60.05,39.42) ; v1(11.67,52.72) 11.67,52.71 9.96,51 4.27,51 v1(3.38,50.11) ; R4.1 v1(137.53,2.4) ; R6.2 C11.2 12.62,60.71 13.13,60.2 13.13,55.65 12.01,54.53
  vias: v1(11.67,53.72) v1(12.67,53.72) v1(12.67,52.72) v1(13.67,53.72) v1(13.67,52.72) v1(34.52,47.37) v1(51.12,17.51) v1(51.12,16.51) v1(52.12,17.51) v1(52.12,16.51) v1(53.12,17.51) v1(53.12,16.51)
VCC5V0_USB20_HOST: length 16.7
  ART04 w0.508: J11.10 120.19,77.18 ; J11.10 119.46,76.45 ; J11.10 119.46,77.91 ; J11.10 118.73,77.18 ; 137.36,77.52 J12.7 ; J12.7 136.38,78.5 ; J12.7 137.36,79.48 ; J12.7 138.33,78.5
  BOTTOM w1.016: J12.1 J12.7 137.57,78.71 137.57,85.29
VCC5V0_USB30_HOST: length 5.1
  BOTTOM w0.762: J11.1 119.46,85.44
VCC_1V8_S3: length 125.4
  TOP w0.254: 37.71,49.67 v1(30.87,49.67) 29.68,49.67 28.35,48.34 v1(25.83,48.34)
  TOP w0.381: v1(42.59,55.56) 39.56,55.56 38.25,54.25 38.25,50.19 37.73,49.67 37.71,49.67 38.55,48.83 v1(39.67,48.83)
  ART03 w0.381: v1(42.59,55.56) 42.72,55.69 42.72,59 41.99,59.74 41.99,66.45 42.57,67.03 44.07,67.03 44.48,67.44 45.9,67.44 47.99,65.34 53.24,65.34 v1(53.69,64.9) 54.51,65.72 54.51,66.67 56.11,68.28 69.93,68.28 72.14,66.07 72.14,64.2 v1(72.31,64.02)
  BOTTOM w0.254: v1(25.83,48.34) 26.38,48.89 R156.1 ; R159.1 76.19,63 74.55,64.64 72.93,64.64 v1(72.31,64.02) ; R158.1 56.02,64.64 53.94,64.64 v1(53.69,64.9) ; R28.1 v1(30.87,49.67)
  BOTTOM w0.508: J30.1 92.7,2.69 80.77,2.69 80.26,2.18 65.94,2.18 65.43,2.69 65.43,4.85 65,5.28 65,7.39 64.39,8 59.82,8 59.09,8.73 D58.2
  vias: v1(56.47,13.87) v1(56.47,12.87)
VCC_3V3_S0: length 105.1
  ART03 w0.508: v1(128.1,17.7) 126.47,16.07 126.47,13.92 125.6,13.06 113.84,13.06 109.8,9.02 109.8,7.01 108.61,5.82 98.63,5.82 94.26,1.45 62.53,1.45 61.37,2.62 61.37,6.5 58.32,9.55 58.32,10.77 57.23,11.86 53.61,11.86 53.1,12.37 53.1,15.49 v1(54.12,16.51) v1(54.12,17.51)
  BOTTOM w0.305: J4.4 132.49,18.51 C21.1 132.45,18.48 131.88,17.91 130.42,17.91 C20.1 129.79,18.48 129.24,17.93 128.33,17.93 v1(128.1,17.7)
  vias: v1(55.12,17.51) v1(55.12,16.51)
VCC_RTC: length 14.6
  BOTTOM w0.254: D9.3 34.12,53.45 33.66,53.92 30.23,53.92 29.49,53.18 29.49,50.3 29.84,49.94 R157.1 R32.1
  BOTTOM w0.305: U5.8 32.42,51.35 C26.1
  BOTTOM w0.381: D9.3 33.5,52.32 33,51.82 C26.1
VCCA1V8_PLDO2_S0: length 19.7
  TOP w0.254: v1(56.12,16.51) 56.12,15.99 56.32,15.79 CN4.21
  BOTTOM w0.254: v1(39.67,49.83) 40.52,50.67 42.55,50.67 44.55,52.68 55.1,52.68 R15.1
VDD_3V3: length 285.5
  TOP w0.203: U8.28 80.32,59.84 80.51,59.65 80.72,59.87 U8.29 ; U7.28 61.91,59.86 62.1,59.66 62.31,59.87 U7.29
  TOP w0.254: R21.1 v1(140.59,6.78) ; v1(49.17,69.8) 49.47,69.8 R87.1 ; R141.1 v1(104.19,54.86) ; v1(78.23,54.13) R58.1 R57.1 ; v1(35.56,83.54) 36.25,82.85 36.25,70.33 35.88,69.97 v1(35.88,68.33) ; 62.1,59.66 62.1,59.46 62.33,59.23 63.09,59.23 64.02,58.31 C33.1 ; R82.2 R91.1 L9.1 v1(44.74,68.95) ; U29.5 v1(7.31,68.09) ; R142.1 v1(100.76,54.86) ; v1(60.83,54.13) R33.1 R34.1 59.82,54.1 59.31,53.59 58.29,53.59 57.78,54.1 R35.1 ; v1(74.37,13.84) 74.4,13.87 v1(74.4,15.95) v1(74.4,17.07) 71.25,20.22 v1(71.25,22.86) ; C51.1 81.49,59.23 80.7,59.23 80.51,59.42 80.51,59.65 ; U28.5 v1(3.44,78.48)
  TOP w0.305: C51.1 C50.1 C49.1 82.37,55.88 81.36,54.87 R59.1 v1(81.28,54.13)
  TOP w0.381: v1(13.44,32.03) 12.99,32.03 L15.2 ; R127.1 v1(131.32,54.15) ; U35.5 14.35,16.59 14.04,16.9 C196.1 v1(12.7,16.1) ; L16.1 v1(38.35,10.63) ; U34.5 21.72,16.59 21.4,16.9 C189.1 v1(19.94,16.1) ; v1(41.12,68.5) 40.44,67.82 36.39,67.82 v1(35.88,68.33) ; R22.1 v1(135.53,8.5)
  TOP w0.508: L8.1 54.77,60.84 v1(54.9,60.97) ; C34.1 v1(64.02,56.58) C35.1 C33.1
  ART03 w0.254: v1(100.76,54.86) v1(104.19,54.86) 106.45,54.86 108.31,56.73 v1(108.31,66.79) ; v1(16.81,65.74) 16.28,65.2 7.82,65.2 7.31,65.71 v1(7.31,68.09)
  ART03 w0.508: v1(12.7,16.1) 14.73,16.1 15.24,15.6 19.43,15.6 v1(19.94,16.1)
  ART04 w0.254: v1(84.26,60.58) 86.16,60.58 86.94,61.37 89.28,61.37
  ART04 w0.508: v1(30.91,30.75) 30.42,30.75 29.87,30.2 ; J32.17 145.71,43.99 ; J32.17 144.73,44.97 ; J32.17 144.73,43.01 ; J32.17 143.75,43.99
  BOTTOM w0.254: R188.1 R163.1 94.1,13.09 93.6,13.59 93.6,17.02 94.11,17.53 95.5,17.53 96.13,18.15 R189.1 ; R235.1 v1(74.4,15.95) ; v1(74.37,13.84) R160.1 R162.1 ; 38.94,68.28 39.19,68.02 U11.13 ; 38.94,68.28 38.69,68.03 U11.12 ; 38.94,68.28 38.94,68.55 38.73,68.76 37.08,68.76 36.83,68.5 36.83,67.82 36.58,67.56 C91.1 ; U11.3 41.34,65.84 C92.1 41.92,66.4 R109.1 ; R238.1 R237.1 71.64,23.25 v1(71.25,22.86) ; v1(16.81,65.74) 17.26,65.29 R3.1 ; R144.1 140.96,6.41 v1(140.59,6.78) 140.49,6.88 137.45,6.88 R145.1 ; Q7.1 104.19,64.81 R146.1 106.56,66.03 v1(107.31,66.79) ; v1(3.44,78.48) 3.44,78.49 C176.1 5.46,78.37 5.46,77.34 6.34,76.46 C177.1 7.04,67.82 v1(7.31,68.09) ; R189.1 R190.1 ; R189.1 96.16,18.16 96.75,17.58 102.95,17.58 105.16,15.36 v1(105.16,11.12) ; R53.1 58.67,61.98 R48.1 R47.1 59.67,59.95 R46.1 65.22,59.95 v1(65.85,60.58) ; R77.1 77.21,62.99 R72.1 R71.1 78.34,59.83 R70.1 83.5,59.83 v1(84.26,60.58) 84.81,61.13 84.81,61.83 R150.1 ; R103.1 81.42,54.26 v1(81.28,54.13) ; L5.1 v1(57.42,68.87) ; R236.1 v1(74.4,17.07) ; R139.1 89.38,63.1 89.38,63.65 89.64,63.91 90.32,63.91 90.61,64.2 Q6.1 89.9,64.81 v1(89.59,65.13) ; U25.5 v1(124.14,16.65) ; v1(30.91,30.75) 30.17,31.49 30.17,32.43 30.53,32.79 32.44,32.79 36.65,37.01 49.08,37.01 R240.1 R239.1 ; R12.1 v1(140.96,2.64) ; R97.2 v1(35.56,83.54)
  BOTTOM w0.305: v1(81.37,47.27) 81.41,47.23 R136.1 ; L7.1 v1(75.83,68.87)
  BOTTOM w0.381: L17.1 33.53,10.63 32.53,9.63 v1(32.51,9.63) ; C91.1 v1(35.88,68.33) 35.88,69.07 35.43,69.52 33.6,69.52 32.49,70.64 18.11,70.64 17.4,69.93 17.4,66.32 v1(16.81,65.74) ; R109.1 42.92,65.18 43.37,64.74 44.09,64.74 44.35,65 44.35,66.62 44.86,67.13 44.86,68.83 v1(44.74,68.95)
  vias: v1(53.9,10.18) v1(53.9,9.18) v1(54.9,10.18) v1(54.9,9.18) v1(68.55,8.97) v1(69.6,8.97) v1(70.6,8.97) v1(70.6,7.97) v1(107.31,67.79) v1(108.31,67.79) v1(114.92,42.27) v1(115.92,42.27) v1(123.14,17.65) v1(123.14,16.65) v1(129.32,68.04) v1(129.32,67.04) v1(130.32,68.04) v1(130.32,67.04)
VDD_5V: length 39.8
  TOP w0.254: Q1.2 49.59,55.68 v1(49.96,55.31) ; R126.1 v1(129.29,57.59) ; v1(11.14,13.84) 11.13,13.84 C151.1 ; R10.1 49.5,54.51 v1(49.96,54.51) ; C153.1 11.13,29.72 v1(11.14,29.71)
  TOP w0.381: U35.3 15.62,21.84 C197.1 v1(14.96,21.97) ; U34.3 22.99,21.84 C190.1 v1(22.33,21.97)
  ART04 w0.508: 146.29,64.31 J32.2 ; J32.2 147.27,65.29 ; J32.2 147.27,63.33 ; J32.2 148.25,64.31 ; J32.4 147.27,62.75 ; J32.4 147.27,60.79 ; J32.4 146.29,61.77 ; J32.4 148.25,61.77
  BOTTOM w0.254: U24.5 v1(117.54,16.65) ; v1(103.54,65.82) 103.27,65.54 100.97,65.54 R147.1 ; C155.1 v1(11.13,25.78) ; Q10.1 88.16,65.66 91.32,65.66 R140.1 ; R1.2 C2.2 18.59,61.72 19.1,61.21 19.1,56.9 17.26,55.06 C8.1
  vias: v1(9.93,47.09) v1(10.74,47.09) v1(11.14,30.71) v1(11.13,24.78) v1(11.14,12.84) v1(17.67,53.72) v1(17.67,52.72) v1(18.67,53.72) v1(18.67,52.72) v1(19.67,53.72) v1(19.67,52.72) v1(27.97,59.64) v1(27.97,58.64) v1(33.66,79.12) v1(33.66,78.12) v1(34.65,79.12) v1(34.65,78.12) v1(73.24,8.97) v1(74.3,8.97) v1(75.29,8.97) v1(75.29,7.97) v1(94.31,66.3) v1(94.31,65.3) v1(116.3,88.1) v1(116.3,87.1) v1(116.54,17.65) v1(116.54,16.65) v1(117.53,87.1) v1(132.68,88.1) v1(132.68,87.1) v1(133.91,87.1)
BAT_RTC: length 6.9
  BOTTOM w0.381: D9.1 36.89,53.28 C24.1 38.01,53.5 D10.2 38.73,54.86 39.49,55.62 J5.1
BM8563_INT: length 9.9
  BOTTOM w0.152: R157.2 R32.2 28.83,47.95 D18.1 ; Q3.1 25.43,49.53 27.25,49.53 D18.1 ; D18.1 28.17,49.58 28.17,52.37 27.89,52.65 U5.3
BOOT_SARADC_IN0: length 125.4
  TOP w0.152: CN4.29 57.92,15.99 57.61,16.31 57.61,16.99 v1(58.12,17.51) ; v1(133.05,67.08) 132.55,66.59 132.55,52.67 129.11,49.23 122.86,49.23 122.48,48.84 111.61,48.84 109.58,46.81 109.58,35.08 100.51,26.01 58.65,26.01 v1(57.67,26.99)
  ART03 w0.152: v1(58.12,17.51) 58.12,26.53 v1(57.67,26.99)
  BOTTOM w0.152: v1(133.05,67.08) 133.05,70.17 R27.2
CAM0_PWDN: length 125.9
  TOP w0.152: v1(40.18,51.7) 41.21,50.67 42.44,50.67 42.98,51.21 47.53,51.21 49.68,49.05 49.68,45.82 51.38,44.13 52.61,44.13 53.52,45.04 CN2.7 ; v1(40.37,9.63) 40.54,9.46 40.54,4.93 39.25,3.64 9.29,3.64 8,4.92 8,7.82 6.43,9.4 2.79,9.4 2.59,9.6 2.59,12.09 3.73,13.24 3.73,14.96 4.98,16.21 4.98,18.99 5.33,19.35 J14.15
  ART03 w0.152: v1(40.37,9.63) 40.37,9.64 40.85,10.12 40.85,11.12 40.18,11.79 40.18,16.05 40.59,16.46 40.59,19.05 44.42,22.89 44.42,41.05 40.18,45.29 v1(40.18,51.7)
CAM0_RSTN: length 129.8
  TOP w0.152: v1(41.37,9.63) 41.02,9.28 41.02,4.6 39.58,3.16 9.06,3.16 7.52,4.7 7.52,7.57 6.17,8.92 2.57,8.92 2.11,9.37 2.11,12.29 3.25,13.44 3.25,15.16 4.45,16.36 4.45,19.18 5.04,19.77 5.04,22.54 5.35,22.85 J14.22 ; v1(41.18,51.7) 41.72,51.16 42.24,51.16 42.81,51.72 47.69,51.72 50.22,49.2 50.22,46 51.59,44.63 52.46,44.63 53.12,45.29 CN2.5
  ART03 w0.152: v1(41.37,9.63) 41.37,11.31 40.67,12.01 40.67,15.57 41.54,16.44 41.54,19.09 45.36,22.91 45.36,40.79 40.67,45.49 40.67,51.18 v1(41.18,51.7)
CAM1_PWDN: length 121.6
  TOP w0.152: CN5.71 89.92,15.35 90.72,16.15 v1(90.72,18.51) ; J15.15 5.91,38.55 5.38,38.02 5.38,35.66 4.83,35.1 4.83,34.37 3.86,33.4 3.86,33.04 v1(3.37,32.55)
  BOTTOM w0.152: v1(90.72,18.51) 91.34,19.12 91.34,29.01 89.61,30.73 65.07,30.73 62.2,33.6 43.61,33.6 42.27,32.26 42.27,30.12 41.2,29.06 31.37,29.06 30.68,29.74 16.21,29.74 15.8,29.34 12.95,29.34 12.34,28.73 9.35,28.73 8.79,28.17 3.15,28.17 2.62,28.7 2.62,31.79 v1(3.37,32.55)
CAM1_RSTN: length 125.5
  TOP w0.152: J15.22 5.17,42.05 4.88,41.76 4.88,35.86 4.32,35.31 4.32,34.57 3.37,33.62 v1(3.37,33.55) ; v1(90.72,19.51) 90.22,19 90.22,16.18 89.52,15.48 CN5.69
  BOTTOM w0.152: v1(90.72,19.51) 90.72,28.68 89.18,30.23 64.9,30.23 62.03,33.1 43.94,33.1 42.8,31.95 42.8,29.84 41.5,28.55 30.94,28.55 30.51,28.98 28.98,28.98 28.52,28.52 15.98,28.52 15.67,28.83 13.26,28.83 12.65,28.22 9.65,28.22 9.12,27.69 2.9,27.69 2.13,28.45 2.13,32.31 v1(3.37,33.55)
CAM2_PWDN: length 121.2
  TOP w0.152: CN5.73 90.32,15.24 91.24,16.15 91.24,19.2 91.54,19.51 v1(92.72,19.51)
  ART03 w0.152: v1(30.91,31.75) 31.42,31.24 v1(31.42,22.96)
  BOTTOM w0.152: v1(30.91,31.75) 31.39,31.27 32.19,31.27 32.41,31.05 32.41,30.38 32.66,30.12 34.39,30.12 35.1,30.83 39.01,30.83 42.75,34.57 62.57,34.57 65.57,31.57 90.58,31.57 92.37,29.78 92.37,19.86 v1(92.72,19.51) ; J16.15 7.63,16.85 8.31,17.53 8.31,19.13 12.22,23.04 22.02,23.04 22.81,22.25 24.31,22.25 25.03,22.97 31.41,22.97 v1(31.42,22.96)
CAM2_RSTN: length 94.8
  TOP w0.152: v1(42.14,51.74) 42.6,52.2 47.95,52.2 50.8,49.35 50.8,46.13 51.79,45.14 52.4,45.14 52.72,45.46 CN2.3
  ART03 w0.152: v1(42.14,51.74) 42.14,51.71 41.27,50.85 41.27,45.64 45.85,41.07 45.85,22.58 v1(42.31,19.05)
  BOTTOM w0.152: J16.22 9.33,13.35 10.49,12.19 11.48,12.19 12.04,12.75 14.66,12.75 15.39,13.49 15.39,17.14 17.42,19.18 25.76,19.18 26.7,18.24 38.71,18.24 39.52,19.05 v1(42.31,19.05)
CAM3_PWDN: length 146.7
  TOP w0.152: J18.15 4.96,57.37 4.72,57.61 4.72,59.56 4.42,59.87 v1(2.5,59.87) ; v1(89.72,19.51) 89.2,18.99 89.2,16.21 88.72,15.73 CN5.65
  BOTTOM w0.152: v1(89.72,19.51) 89.72,27.8 88.26,29.26 64.44,29.26 61.59,32.11 44.53,32.11 43.87,31.45 43.87,29.21 42.19,27.53 15.95,27.53 15.65,27.23 10.19,27.23 9.58,26.62 2.49,26.62 1.17,27.94 1.17,48.31 1.65,48.79 1.65,59.02 v1(2.5,59.87)
CAM3_RSTN: length 146.2
  TOP w0.152: CN5.67 89.12,15.59 89.72,16.19 v1(89.72,18.51) ; J18.22 v1(2.5,60.87)
  BOTTOM w0.152: v1(2.5,60.87) 3.02,60.34 3.02,59.51 2.13,58.62 2.13,48.44 1.65,47.96 1.65,28.19 2.74,27.1 9.3,27.1 9.91,27.71 15.45,27.71 15.78,28.04 28.73,28.04 29.18,28.5 30,28.5 30.45,28.04 41.83,28.04 43.31,29.51 43.31,31.65 44.25,32.59 61.82,32.59 64.67,29.74 88.7,29.74 90.22,28.22 90.22,18.95 89.78,18.51 v1(89.72,18.51)
CAM4_PWDN: length 73.7
  TOP w0.152: CN2.9 53.92,44.88 52.63,43.59 41.68,43.59 37.97,47.29 35.64,47.29 34.75,48.18 30.15,48.18 28.85,46.89 27.05,46.89 25.73,45.57 23.44,45.57 21.64,47.37 18.26,47.37 16.59,49.05 15.76,49.05 v1(15.24,49.56)
  BOTTOM w0.152: v1(15.24,49.56) 4.76,49.56 2.62,47.42 2.62,36.47 3.04,36.05 J17.15
CAM4_RSTN: length 77.9
  TOP w0.152: v1(25.27,46.14) 24.65,46.76 23.06,46.76 21.97,47.85 18.73,47.85 17.02,49.56 v1(16.24,49.56) ; CN2.11 54.32,44.72 52.7,43.1 41.43,43.1 37.85,46.69 34.26,46.69 33.27,47.68 30.4,47.68 29.08,46.35 27.83,46.35 v1(26.69,45.21)
  BOTTOM w0.152: v1(16.24,49.56) 15.67,50.14 4.57,50.14 2.13,47.7 2.13,35.74 5.32,32.55 J17.22 ; v1(25.27,46.14) 25.76,46.14 v1(26.69,45.21)
CAN0_H: length 15.1
  TOP w0.203: U34.7 24.26,14.07 23.78,13.6 23.78,13.2 23.33,12.75 22.33,12.75 22.08,12.5 22.08,12.08 R205.1 D57.1 23.38,11.23 23.17,11.02 22.23,11.02 22.02,10.82 22.02,9.99 19.74,7.7 19.74,6.35 20.04,6.05 J29.1
CAN0_L: length 15.4
  TOP w0.203: U34.6 22.99,14.07 23.43,13.63 23.43,13.35 23.19,13.11 22.18,13.11 21.72,12.64 21.72,12.19 R205.2 D47.1 20.31,11.28 20.52,11.07 21.41,11.07 21.67,10.82 21.67,10.13 19.38,7.85 19.38,6.35 19.08,6.05 J29.2
CAN0_RX_M2: length 76.4
  TOP w0.152: CN5.58 87.12,11.58 v1(86.72,11.18) ; U34.4 21.72,18.82 22.91,17.63 28.37,17.63 28.77,17.22 40.34,17.22 41.81,18.69 41.81,21.22 v1(42.56,21.97)
  BOTTOM w0.152: v1(86.72,11.18) 85.88,11.18 84.74,12.31 84.74,13.38 83.69,14.43 81.86,14.43 78.27,18.02 66.15,18.02 62.81,21.36 43.17,21.36 v1(42.56,21.97)
CAN0_TX_M2: length 74.7
  TOP w0.152: U34.1 25.53,18.31 25.83,18.01 28.52,18.01 28.93,17.6 40.08,17.6 41.35,18.87 41.35,21.77 v1(41.56,21.97) ; v1(87.22,13.02) 87.52,12.72 CN5.60
  BOTTOM w0.152: v1(87.22,13.02) 86.73,13.51 85.17,13.51 83.77,14.91 82.07,14.91 80.54,16.43 80.54,18.8 79.6,19.74 77.93,19.74 77.19,19 74.24,19 73.91,18.67 66.29,18.67 63.2,21.77 43.74,21.77 43.05,22.45 42.04,22.45 v1(41.56,21.97)
CAN1_H: length 15.6
  TOP w0.203: U35.7 16.89,14.3 16.35,13.76 16.35,13.21 15.94,12.8 15.6,12.8 15.44,12.65 15.44,12.11 R206.1 D30.1 16.77,11.39 16.48,11.1 15.67,11.1 15.42,10.85 15.42,9.5 14.19,8.28 12.75,8.28 12.09,7.62 12.09,6.4 12.44,6.05 J29.3
CAN1_L: length 15.9
  TOP w0.203: J29.4 11.48,6.05 11.73,6.3 11.73,7.77 12.6,8.64 14.05,8.64 15.06,9.65 15.06,10.85 14.78,11.13 13.94,11.13 13.71,11.36 D25.1 R206.2 15.09,12.16 15.09,12.8 15.44,13.16 15.79,13.16 16,13.36 16,13.72 15.62,14.1 U35.6
CAN1_RX_M3: length 59.5
  TOP w0.152: CN4.62 64.32,11.38 v1(64.12,11.18) ; U35.4 14.35,18.49 14.96,17.88 18.29,17.88 18.87,18.47 20.9,18.47 22.48,16.89 28.06,16.89 28.47,16.48 39.57,16.48 39.98,16.08 40.6,16.08 v1(41.13,16.61)
  BOTTOM w0.152: v1(64.12,11.18) 63.12,12.18 63.12,14.71 62.36,15.47 62.36,16.51 60.81,18.06 46.14,18.06 44.95,16.87 41.39,16.87 v1(41.13,16.61)
CAN1_TX_M3: length 53.2
  TOP w0.152: v1(40.13,16.61) 39.9,16.84 28.61,16.84 28.21,17.25 22.66,17.25 21.08,18.82 18.39,18.82 18.16,19.05 U35.1 ; CN4.60 63.92,12.57 v1(63.62,12.87)
  BOTTOM w0.152: v1(40.13,16.61) 40.82,17.3 44.77,17.3 45.94,18.47 60.91,18.47 63.62,15.75 v1(63.62,12.87)
CTP_INT: length 157.5
  TOP w0.152: v1(96.5,30.03) 96.5,30.4 95.67,31.23 56.14,31.23 54,29.08 52.28,29.08 51.67,28.47 v1(51.67,27.99) ; v1(139.75,4.14) 140.23,3.65 141.2,3.65 141.5,3.96 141.5,6.12 143.81,8.43 147.73,8.43 148.13,8.84 148.13,14.99 145.57,17.55 J13.11 141.15,17.55 139.83,18.87 v1(139.83,19.56) ; v1(53.92,51.79) 54.41,51.3 54.41,50.47 54.72,50.15 CN2.14
  ART03 w0.152: v1(51.67,27.99) 51.28,28.37 51.28,47.7 53.34,49.76 53.34,51.23 53.89,51.79 v1(53.92,51.79) ; v1(139.83,19.56) 139.09,18.82 137.64,18.82 136.33,20.13 132.19,20.13 129.67,22.66 123.7,22.66 122.63,23.72 97.66,23.72 96.5,24.89 v1(96.5,30.03)
  BOTTOM w0.152: R144.2 139.96,4.35 v1(139.75,4.14)
CTP_RST: length 161.4
  TOP w0.152: v1(54.92,50.79) 54.92,50.54 55.12,50.34 CN2.16 ; v1(52.67,27.99) 53.17,27.48 54.53,27.48 57.1,30.05 94.48,30.05 v1(94.5,30.03) ; v1(137.94,4.14) 138.9,3.17 141.68,3.17 141.99,3.48 141.99,5.87 144.07,7.95 147.93,7.95 148.62,8.64 148.62,15.34 145.91,18.05 J13.12 v1(142.39,18.05)
  ART03 w0.152: v1(142.39,18.05) 142.39,17.09 142.06,16.76 141.11,16.76 140.75,16.41 137.01,16.41 135.64,17.78 131.34,17.78 129.72,19.41 124.21,19.41 123.72,18.92 110.24,18.92 109.47,18.16 97.54,18.16 94.01,21.68 94.01,29.42 94.5,29.91 v1(94.5,30.03) ; v1(54.92,50.79) 54.92,49.64 52.76,47.47 52.76,46.69 52.37,46.3 52.37,29.34 52.67,29.05 v1(52.67,27.99)
  BOTTOM w0.152: R145.2 137.53,4.54 v1(137.94,4.14)
DP_TX_AUXN: length 116.5
  TOP w0.109: v1(33.91,31.62) 34.12,31.4 arc(34.23,31.33) 34.35,31.31 35.73,31.31 arc(35.98,31.26) 36.19,31.12 36.46,30.85 arc(36.53,30.8) 36.62,30.78 39.97,30.78 arc(40.45,30.88) 40.85,31.15 41.69,31.99 arc(42.19,32.32) 42.78,32.44 76.21,32.44 arc(76.96,32.58) 77.58,33 84.63,40.05 arc(85.05,40.68) 85.2,41.42 85.2,45.3 85.12,45.38 CN3.47
  ART03 w0.089: v1(21.06,76.5) 20.86,76.3 arc(20.72,76.21) 20.56,76.16 20.56,76.16 arc(20.28,76.02) 20.17,75.74 20.17,75.71 arc(20.25,75.32) 20.47,74.98 24.92,70.53 arc(25.21,70.34) 25.55,70.27 25.86,70.27 arc(26.01,70.24) 26.14,70.15 28.52,67.77 arc(28.61,67.64) 28.64,67.49 28.64,61.04 arc(28.71,60.7) 28.9,60.41 31.33,57.98 arc(31.42,57.85) 31.45,57.7 31.45,50.77 arc(31.51,50.43) 31.71,50.14 32.13,49.71 arc(32.23,49.58) 32.26,49.42 32.26,41.03 arc(32.39,40.35) 32.78,39.77 34.53,38.02 arc(34.62,37.89) 34.65,37.74 34.65,31.6 arc(34.62,31.49) 34.56,31.4 34.52,31.36 arc(34.46,31.32) 34.39,31.31 34.33,31.31 arc(34.23,31.33) 34.13,31.39 v1(33.91,31.62)
  BOTTOM w0.109: C106.2 22.98,76.72 arc(23.08,76.57) 23.12,76.4 23.12,76.3 arc(23.08,76.22) 23.01,76.19 21.5,76.19 arc(21.37,76.21) 21.27,76.28 v1(21.06,76.5)
DP_TX_AUXP: length 117.7
  TOP w0.109: CN3.49 85.52,45.38 85.45,45.3 85.45,41.42 arc(85.28,40.58) 84.81,39.87 77.76,32.83 arc(77.05,32.35) 76.21,32.19 42.78,32.19 arc(42.28,32.09) 41.86,31.81 41.03,30.97 arc(40.54,30.65) 39.97,30.54 36.62,30.54 arc(36.44,30.57) 36.29,30.67 36.02,30.94 arc(35.89,31.03) 35.73,31.06 34.24,31.06 arc(34.12,31.04) 34.02,30.97 33.91,30.86 v1(33.91,30.75)
  ART03 w0.089: v1(33.91,30.75) 33.91,30.94 34.06,31.09 34.11,31.09 34.14,31.12 34.39,31.12 arc(34.54,31.15) 34.66,31.23 34.7,31.27 arc(34.8,31.42) 34.84,31.6 34.84,37.74 arc(34.79,37.97) 34.66,38.16 32.91,39.91 arc(32.57,40.42) 32.45,41.03 32.45,49.42 arc(32.4,49.65) 32.27,49.85 31.84,50.28 arc(31.69,50.5) 31.64,50.77 31.64,57.7 arc(31.59,57.92) 31.46,58.11 29.03,60.54 arc(28.88,60.77) 28.83,61.04 28.83,67.49 arc(28.78,67.71) 28.66,67.9 26.27,70.29 arc(26.08,70.42) 25.86,70.46 25.55,70.46 arc(25.28,70.51) 25.06,70.66 20.6,75.12 arc(20.42,75.39) 20.36,75.71 20.36,75.74 arc(20.42,75.89) 20.57,75.97 arc(20.58,75.97) 20.59,75.97 20.9,75.97 arc(21.01,75.92) 21.06,75.81 v1(21.06,75.63)
  BOTTOM w0.109: v1(21.06,75.63) 21.27,75.85 arc(21.37,75.92) 21.5,75.94 23.01,75.94 arc(23.26,76.05) 23.37,76.3 23.37,76.33 arc(23.41,76.57) 23.55,76.77 C105.2
DSI_VDD3V3:
  vias: v1(140.4,13.89) v1(141.4,13.89) v1(142.4,13.89)
DSI_VDD5V:
  vias: v1(142.4,11.97) v1(142.4,10.97) v1(143.4,11.97) v1(143.4,10.97)
EARPHONE_CTL: length 72.3
  TOP w0.152: v1(92.52,50.79) 92.52,50.51 91.72,49.71 91.34,49.71 91.12,49.49 CN3.78
  ART03 w0.152: v1(43.18,71.25) 43.74,71.81 49.86,71.81 50.44,71.22 88.9,71.22 90.2,69.93 90.2,66.24 90.6,65.84 90.6,62.15 91.67,61.09 91.67,57.99 91.52,57.84 91.52,56.44 93.04,54.91 93.04,51.3 v1(92.52,50.79)
  BOTTOM w0.152: R95.2 v1(43.18,71.25)
ETH0_MCLK_M0: length 56.8
  TOP w0.102: v1(75.72,20.51) 76.01,20.22 77.29,20.22 77.57,19.94 78.56,19.94 79.38,19.13 79.38,18.24 79.12,17.98 CN5.17 ; R49.1 v1(68.78,60.83)
  ART03 w0.097: v1(75.72,20.51) 76.22,21.01 78.65,21.01 78.92,21.28 78.92,35.67 73.58,41 73.58,53.53 72.36,54.76 72.36,56.36 69.27,59.45 69.27,60.35 v1(68.78,60.83)
ETH0_MDC_M0: length 97.9
  TOP w0.152: U7.13 56.02,63.86 v1(55.91,63.98) ; CN5.48 85.12,12.92 v1(85.22,13.02)
  ART03 w0.152: v1(55.91,63.98) 55.35,63.98 53.49,62.13 53.49,57.18 55.3,55.37 55.3,54 56.54,52.76 62.79,52.76 63.45,52.1 63.45,50.5 63.25,50.29 62.66,50.29 61.82,49.45 61.82,47.98 62.38,47.42 62.38,42.67 62.99,42.06 62.99,33.2 65.79,30.4 65.79,20.7 70.1,16.38 70.1,14.48 70.56,14.02 70.56,11.35 71.04,10.87 71.04,6.86 71.5,6.4 75.9,6.4 76.12,6.17 83.26,6.17 85.22,8.13 v1(85.22,13.02)
  BOTTOM w0.152: v1(55.91,63.98) 56.41,63.47 56.41,62.69 57.12,61.98 R48.2
ETH0_MDIO_M0: length 94.2
  TOP w0.152: U7.14 56.39,63.47 v1(55.9,62.97) ; CN5.46 v1(84.72,11.18)
  ART03 w0.152: v1(84.72,11.18) 84.72,8.37 82.91,6.55 76.58,6.55 76.17,6.96 71.91,6.96 71.6,7.26 71.6,11.18 71.13,11.65 71.13,14.36 70.66,14.83 70.66,16.54 66.37,20.83 66.37,30.61 64.11,32.87 64.11,42.16 63.35,42.93 63.35,47.45 63.04,47.75 62.59,47.75 62.18,48.16 62.18,49.35 62.74,49.91 63.92,49.91 64.33,50.32 64.33,52.18 63.32,53.19 56.85,53.19 55.83,54.2 55.83,55.52 54,57.35 54,61.95 55.02,62.97 v1(55.9,62.97)
  BOTTOM w0.152: R47.2 57.61,60.96 55.9,62.67 v1(55.9,62.97)
ETH0_RSTN: length 100.7
  TOP w0.152: CN5.50 85.52,12.57 85.97,13.02 v1(86.22,13.02)
  ART03 w0.152: v1(86.22,13.02) 86.22,8.22 83.51,5.51 70.43,5.51 70.03,5.92 70.03,13.64 69.57,14.1 69.57,16.21 65.3,20.47 65.3,30.02 62.43,32.89 62.43,41.05 61.52,41.96 61.52,45.93 61.21,46.23 61.21,49.43 62.43,50.65 62.43,51.96 62.12,52.27 56.34,52.27 54.72,53.89 54.72,55.19 52.4,57.51 52.4,61.87 55.45,64.92 55.45,65.84 v1(56.9,67.29)
  BOTTOM w0.152: v1(56.9,67.29) 56.9,67.56 55.68,68.78 D59.1
ETH0_RXCLK_M0: length 74.5
  TOP w0.102: R41.1 v1(62.87,56.58) R44.1 ; CN5.22 79.92,11.38 v1(79.72,11.18)
  ART03 w0.097: v1(62.87,56.58) 63.28,56.99 64.98,56.99 65.56,56.41 65.79,56.41 66.83,55.37 66.83,54.58 67.89,53.52 68.28,53.52 69.88,51.92 69.88,50.77 70.21,50.44 70.21,41.27 69.88,40.94 69.88,38.07 70.13,37.82 70.89,37.82 71.55,37.16 71.55,35.81 72.13,35.24 72.13,31.5 72.92,30.7 72.92,26.9 73.09,26.73 73.31,26.73 73.48,26.56 73.48,26.32 73.31,26.15 73.09,26.15 72.92,25.98 72.92,25.76 73.09,25.59 73.97,25.59 74.14,25.42 74.14,25.18 73.97,25.01 73.09,25.01 72.92,24.84 72.92,24.6 73.09,24.43 73.97,24.43 74.14,24.26 74.14,24.02 73.97,23.85 73.09,23.85 72.92,23.68 72.92,23.44 73.09,23.27 73.97,23.27 74.14,23.1 74.14,22.86 73.97,22.69 73.09,22.69 72.92,22.52 72.92,22.2 73.13,22 73.97,22 74.12,21.84 74.12,21.52 73.96,21.36 73.08,21.36 72.92,21.2 72.92,20.88 73.11,20.7 73.94,20.7 74.1,20.54 74.1,20.25 73.94,20.09 73.1,20.09 72.94,19.93 72.94,19.61 73.12,19.43 74.03,19.43 74.19,19.27 74.19,17.93 73.96,17.7 73.96,16.87 74.17,16.66 75.46,16.66 75.72,16.41 75.72,16.18 75.55,16.02 75.02,16.02 74.85,15.85 74.85,15.61 75.02,15.44 75.55,15.44 75.72,15.27 75.72,15.04 75.55,14.87 75.35,14.87 75.18,14.7 75.18,14.46 75.35,14.29 75.55,14.29 75.72,14.12 75.72,12.47 76.2,11.99 76.2,10.92 76.45,10.67 79.21,10.67 v1(79.72,11.18)
ETH0_RXCTL_M0: length 75.6
  TOP w0.102: CN5.24 80.32,12.92 v1(80.22,13.02) ; R42.1 v1(61.85,56.58) R45.1
  ART03 w0.097: v1(61.85,56.58) 62.34,56.08 64.72,56.08 65.38,55.42 65.96,55.42 66.31,55.08 66.31,54.4 67.8,52.91 68.17,52.91 69.45,51.63 69.45,50.55 69.77,50.22 69.77,41.48 69.45,41.15 69.45,39.06 69.28,38.89 68.67,38.89 68.5,38.72 68.5,38.49 68.67,38.32 69.28,38.32 69.45,38.15 69.45,37.92 69.32,37.8 68.61,37.8 68.45,37.64 68.45,37.39 68.59,37.26 70.83,37.26 70.99,37.1 70.99,36.78 70.83,36.62 70.12,36.62 69.96,36.46 69.96,35.76 70.18,35.53 71.22,35.53 71.53,35.23 71.53,35.01 71.36,34.84 70.5,34.84 70.33,34.67 70.33,34.43 70.5,34.26 71.36,34.26 71.53,34.09 71.53,31.17 72.34,30.35 72.34,24.01 72.18,23.85 71.58,23.85 71.42,23.69 71.42,23.37 71.58,23.21 72.15,23.21 72.31,23.05 72.31,22.73 72.15,22.57 71.58,22.57 71.42,22.41 71.42,22.09 71.58,21.93 72.15,21.93 72.31,21.77 72.31,21.45 72.15,21.29 71.58,21.29 71.42,21.13 71.42,20.81 71.58,20.65 72.15,20.65 72.31,20.49 72.31,19.51 73.53,18.29 73.53,16.61 73.99,16.15 73.99,15.52 74.75,14.76 74.75,11.56 76.13,10.18 79.42,10.18 80.22,10.98 v1(80.22,13.02)
ETH0_RXD0_M0: length 74.8
  TOP w0.102: CN5.26 v1(80.72,11.18) ; R37.1 v1(60.83,56.58) R33.2
  ART03 w0.097: v1(80.72,11.18) 80.72,10.82 79.59,9.69 76.01,9.69 74.12,11.58 74.12,13.41 73.74,13.79 73.74,15.09 73.05,15.77 73.05,18.11 70.82,20.35 70.82,24.34 70.98,24.5 71.57,24.5 71.73,24.66 71.73,24.98 71.57,25.14 70.98,25.14 70.82,25.3 70.82,25.62 70.98,25.78 71.57,25.78 71.73,25.94 71.73,26.26 71.57,26.42 70.98,26.42 70.82,26.58 70.82,26.9 70.98,27.06 71.57,27.06 71.73,27.22 71.73,27.54 71.57,27.7 70.98,27.7 70.82,27.86 70.82,28.18 70.98,28.34 71.57,28.34 71.73,28.5 71.73,28.82 71.57,28.98 70.98,28.98 70.82,29.14 70.82,29.46 70.98,29.62 71.57,29.62 71.73,29.78 71.73,30.1 71.57,30.26 70.98,30.26 70.82,30.42 70.82,30.71 70.66,30.87 70.06,30.87 69.9,31.03 69.9,31.35 70.06,31.51 70.66,31.51 70.82,31.67 70.82,31.99 70.66,32.15 70.06,32.15 69.9,32.31 69.9,32.63 70.06,32.79 70.66,32.79 70.82,32.95 70.82,33.27 70.66,33.43 70.06,33.43 69.9,33.59 69.9,33.91 67.92,35.89 67.92,39.19 68.12,39.4 68.78,39.4 68.99,39.6 68.99,41.61 69.35,41.97 69.35,50.03 69.01,50.37 69.01,51.35 68.01,52.35 67.54,52.35 64.31,55.58 61.84,55.58 v1(60.83,56.58)
ETH0_RXD1_M0: length 74.6
  TOP w0.102: R34.2 v1(59.82,56.58) R36.1 ; CN5.28 81.12,12.92 v1(81.22,13.02)
  ART03 w0.097: v1(59.82,56.58) 61.35,55.05 64.2,55.05 67.33,51.92 67.33,51.54 67.61,51.26 68.22,51.26 68.58,50.9 68.58,50.19 68.92,49.85 68.92,44.89 68.4,44.37 68.4,41.22 68.23,41.05 67.12,41.05 66.95,40.88 66.95,40.64 67.12,40.47 68.23,40.47 68.4,40.3 68.4,40.08 68.22,39.9 67.69,39.9 67.44,39.65 67.44,35.59 69.19,33.83 69.19,30.4 69.39,30.2 69.95,30.2 70.18,29.97 70.18,22.85 70.02,22.69 69.45,22.69 69.29,22.53 69.29,22.21 69.45,22.05 70.05,22.05 70.21,21.89 70.21,21.57 70.05,21.41 69.45,21.41 69.29,21.25 69.29,20.93 69.45,20.77 70.05,20.77 70.21,20.61 70.21,20.29 72.49,18.01 72.49,15.6 73.13,14.96 73.13,13.69 73.46,13.36 73.46,11.61 76.02,9.04 76.73,9.04 77.22,8.56 79.07,8.56 81.22,10.71 v1(81.22,13.02)
ETH0_RXD2_M0: length 75.1
  TOP w0.102: v1(81.72,11.18) 81.52,11.38 CN5.30 ; R39.1 v1(58.8,56.58) R43.1
  ART03 w0.097: v1(81.72,11.18) 81.72,10.6 79.2,8.08 76.96,8.08 76.66,8.38 75.08,8.38 74.83,8.63 74.83,9.63 72.82,11.63 72.82,13.31 72.59,13.54 72.59,14.76 71.96,15.39 71.96,17.51 68.64,20.83 68.64,23.35 68.8,23.51 69.46,23.51 69.62,23.67 69.62,23.99 69.46,24.15 68.8,24.15 68.64,24.31 68.64,24.63 68.8,24.79 69.46,24.79 69.62,24.95 69.62,25.27 69.46,25.43 68.8,25.43 68.64,25.59 68.64,27.39 68.8,27.55 69.23,27.55 69.39,27.71 69.39,28.03 69.23,28.19 68.8,28.19 68.64,28.35 68.64,28.67 68.8,28.83 69.23,28.83 69.39,28.99 69.39,29.31 69.23,29.47 68.8,29.47 68.64,29.63 68.64,33.51 66.4,35.76 66.4,41.33 67.41,42.34 67.41,44.2 68.49,45.28 68.49,49.64 67.77,50.37 66.78,50.37 66.52,50.62 66.52,51.79 63.75,54.56 60.82,54.56 v1(58.8,56.58)
ETH0_RXD3_M0: length 74.8
  TOP w0.102: v1(82.22,13.02) 81.92,12.72 CN5.32 ; R35.2 v1(57.78,56.58) R40.1
  ART03 w0.097: v1(57.78,56.58) 60.65,53.72 63.71,53.72 65.35,52.07 65.35,50.72 66.24,49.83 67.59,49.83 68.07,49.36 68.07,45.51 67.23,44.68 66.9,44.68 66.5,44.27 66.5,42.24 65.79,41.53 65.79,35.48 67.74,33.53 67.74,21.11 71.42,17.42 71.42,15.16 72.09,14.5 72.09,13.39 72.29,13.18 72.29,11.51 73.81,9.98 73.81,8.89 75.13,7.57 76.5,7.57 76.81,7.26 79.5,7.26 82.22,9.98 v1(82.22,13.02)
ETH0_TXCLK_M0: length 72.7
  TOP w0.102: v1(75.72,21.51) 75.93,21.51 76.4,21.03 77.39,21.03 77.8,20.62 78.71,20.62 79.92,19.42 CN5.21 ; v1(55.9,58.97) 56.41,59.48 57.1,59.48 57.11,59.49 57.11,59.49 57.41,59.78 57.41,60.45 58.02,61.07 U7.20
  ART03 w0.097: v1(75.72,21.51) 76.21,22 76.21,34.7 71.35,39.56 71.35,52.23 69.17,54.41 69.17,55.29 65.99,58.47 63.11,58.47 62.95,58.63 62.95,59.43 62.79,59.59 62.52,59.59 62.36,59.43 62.36,58.68 62.15,58.47 61.88,58.47 61.72,58.63 61.72,59.43 61.56,59.59 61.24,59.59 61.08,59.43 61.08,58.68 60.87,58.47 60.6,58.47 60.44,58.63 60.44,59.43 60.28,59.59 59.96,59.59 59.8,59.43 59.8,58.68 59.59,58.47 59.32,58.47 59.16,58.63 59.16,59.43 59,59.59 58.68,59.59 58.52,59.43 58.52,58.68 58.31,58.47 56.08,58.47 55.9,58.65 v1(55.9,58.97)
ETH0_TXCTL_M0: length 72.2
  TOP w0.102: v1(56.9,59.97) 56.9,60.58 57.79,61.47 U7.19 ; CN5.23 80.32,19.65 78.92,21.06 78.05,21.06 77.61,21.51 v1(76.72,21.51)
  ART03 w0.097: v1(76.72,21.51) 77.21,22 77.21,35.21 72.23,40.19 72.23,52.76 70.79,54.2 70.79,55.42 66.52,59.69 66.52,60.68 66.19,61.01 65.83,61.01 65.67,61.17 65.67,61.51 65.51,61.67 65.19,61.67 65.03,61.51 65.03,61.17 64.87,61.01 64.57,61.01 64.41,61.17 64.41,62.55 64.25,62.71 63.96,62.71 63.8,62.55 63.8,61.09 63.61,60.91 63.32,60.91 63.16,61.07 63.16,61.79 63,61.95 62.68,61.95 62.52,61.79 62.52,61.2 62.33,61.01 62.05,61.01 61.84,60.81 61.41,60.81 61.2,61.01 60.77,61.01 60.56,60.81 60.13,60.81 59.92,61.01 59.49,61.01 59.28,60.81 58.85,60.81 58.64,61.01 57.51,61.01 56.9,60.41 v1(56.9,59.97)
ETH0_TXD0_M0: length 72.5
  TOP w0.102: v1(55.9,59.97) 56.47,60.54 56.47,61 56.81,61.34 57.08,61.34 57.6,61.87 U7.18 ; CN5.25 80.72,19.86 79.06,21.52 v1(78.26,21.52)
  ART03 w0.097: v1(78.26,21.52) 77.72,22.06 77.72,35.41 72.69,40.44 72.69,53.04 71.33,54.4 71.33,55.6 66.95,59.97 66.95,60.96 66.55,61.37 66.55,62.18 66.29,62.43 65.86,62.43 65.07,63.22 63.07,63.22 62.1,62.26 59.1,62.26 58.94,62.09 58.94,61.69 58.74,61.49 58.32,61.49 58.2,61.61 58.2,61.84 58.09,61.95 57.93,61.95 57.82,61.84 57.82,61.61 57.7,61.49 55.52,61.49 55.3,61.26 55.3,60.17 55.49,59.97 v1(55.9,59.97)
ETH0_TXD1_M0: length 72.2
  TOP w0.102: U7.17 57.47,62.27 57.08,61.87 56.62,61.87 55.9,61.15 v1(55.9,60.97) ; v1(76.72,22.51) 77.22,22.01 79.89,22.01 81.12,20.78 CN5.27
  ART03 w0.097: v1(55.9,60.97) 56.2,60.97 56.39,60.78 56.39,59.61 56.62,59.39 57.29,59.39 57.45,59.55 57.45,59.99 57.61,60.15 63.37,60.15 63.53,59.99 63.53,59.14 63.69,58.98 63.95,58.98 64.13,59.16 64.13,59.99 64.29,60.15 64.61,60.15 64.77,59.99 64.77,59.14 64.93,58.98 65.23,58.98 65.41,59.16 65.41,59.99 65.57,60.15 65.89,60.15 66.05,59.99 66.05,59.32 70.24,55.13 70.24,54.03 71.79,52.48 71.79,39.81 76.72,34.88 v1(76.72,22.51)
ETH0_TXD2_M0: length 72.6
  TOP w0.102: v1(78.26,22.52) 80.04,22.52 81.52,21.04 CN5.29 ; v1(55.9,61.97) 56.28,62.36 57.03,62.36 57.34,62.67 U7.16
  ART03 w0.097: v1(78.26,22.52) 78.26,35.64 73.13,40.76 73.13,53.29 71.87,54.55 71.87,55.71 67.49,60.1 67.49,63.66 67.32,63.83 67.07,63.83 66.96,63.72 66.96,63.03 66.84,62.92 66.68,62.92 66.57,63.03 66.57,63.72 66.46,63.83 62.66,63.83 62.23,63.4 58.22,63.4 56.79,61.97 v1(55.9,61.97)
ETH0_TXD3_M0: length 72.3
  TOP w0.102: CN5.31 81.92,21.45 80.38,22.99 76.2,22.99 v1(75.72,22.51) ; v1(56.9,62.97) 56.99,63.07 U7.15
  ART03 w0.097: v1(75.72,22.51) 75.72,34.46 70.92,39.27 70.92,51.97 68.19,54.7 68.19,55.54 66.43,57.29 65.67,57.29 65.13,57.84 55.47,57.84 54.49,58.82 54.49,61.65 55.32,62.48 56.41,62.48 v1(56.9,62.97)
ETH1_MCLK_M0: length 59.8
  TOP w0.102: CN5.18 79.12,12.92 v1(79.22,13.02) ; R73.1 v1(87.17,60.83)
  ART03 w0.097: v1(79.22,13.02) 79.74,13.54 83.24,13.54 86.82,17.12 88.87,17.12 90.3,18.54 90.3,33.73 91.06,34.49 91.06,47.37 88.01,50.42 88.01,54.15 87.63,54.53 87.63,55.19 86.69,56.13 86.69,60.35 v1(87.17,60.83)
ETH1_MDC_M0: length 31.8
  TOP w0.152: CN3.56 86.72,50.3 87.01,50.59 87.01,51.27 v1(87.52,51.79) ; v1(74.31,64.02) 74.47,63.86 U8.13
  ART03 w0.152: v1(87.52,51.79) 87.52,53.68 86.21,54.99 86.21,59.54 84.58,61.16 82.14,61.16 81.23,62.08 77.5,62.08 77.24,62.33 77.24,63.37 76.59,64.02 v1(74.31,64.02)
  BOTTOM w0.152: R72.2 75.62,61.98 74.8,62.79 74.8,63.5 74.31,63.99 v1(74.31,64.02)
ETH1_MDIO_M0: length 31.1
  TOP w0.152: U8.14 74.8,63.47 v1(74.31,62.97) ; CN3.58 87.12,50.01 87.52,50.41 v1(87.52,50.79)
  ART03 w0.152: v1(74.31,62.97) 74.84,63.5 76.12,63.5 76.68,62.94 76.68,60.76 77.47,59.97 84.05,59.97 85.67,58.34 85.67,54.71 87,53.39 87,51.26 87.47,50.79 v1(87.52,50.79)
  BOTTOM w0.152: R71.2 76.07,60.96 74.31,62.72 v1(74.31,62.97)
ETH1_RSTN: length 32.1
  TOP w0.152: CN3.60 87.52,49.91 88.04,50.42 88.04,51.3 v1(88.52,51.79)
  ART03 w0.152: v1(75.31,67.29) 76.41,66.19 84.79,66.19 88.49,62.48 88.49,58.8 87.74,58.05 87.74,55.95 88.58,55.11 88.58,51.84 v1(88.52,51.79)
  BOTTOM w0.152: v1(75.31,67.29) 75.31,67.44 73.97,68.78 D60.1
ETH1_RXCLK_M0: length 70.2
  TOP w0.102: CN5.4 76.32,12.92 v1(76.22,13.02) ; R59.2 v1(81.28,56.58) R67.1
  ART03 w0.097: v1(76.22,13.02) 76.22,14.63 78.21,16.61 82.25,16.61 84.96,19.32 84.96,20.96 85.12,21.12 85.54,21.12 85.7,21.28 85.7,21.6 85.54,21.76 85.12,21.76 84.96,21.92 84.96,22.24 85.12,22.4 85.54,22.4 85.7,22.56 85.7,22.88 85.54,23.04 85.12,23.04 84.96,23.2 84.96,23.52 85.12,23.68 85.54,23.68 85.7,23.84 85.7,24.16 85.54,24.32 85.12,24.32 84.96,24.48 84.96,24.8 85.12,24.96 85.54,24.96 85.7,25.12 85.7,25.44 85.54,25.6 85.12,25.6 84.96,25.76 84.96,26.05 85.12,26.21 85.56,26.21 85.72,26.37 85.72,26.69 85.56,26.85 85.12,26.85 84.96,27.01 84.96,27.33 85.12,27.49 85.56,27.49 85.72,27.65 85.72,27.97 85.56,28.13 85.12,28.13 84.96,28.29 84.96,28.61 85.12,28.77 86.07,28.77 86.23,28.93 86.23,29.25 86.07,29.41 85.12,29.41 84.96,29.57 84.96,29.89 85.12,30.05 86.07,30.05 86.23,30.21 86.23,30.53 86.07,30.69 85.12,30.69 84.96,30.85 84.96,31.17 85.12,31.33 86.07,31.33 86.23,31.49 86.23,31.81 86.07,31.97 85.12,31.97 84.96,32.13 84.96,32.45 85.12,32.61 86.07,32.61 86.23,32.77 86.23,33.09 86.07,33.25 85.12,33.25 84.96,33.41 84.96,44.57 85.32,44.93 85.32,46.96 85.01,47.27 84,47.27 81.94,49.33 81.94,50.24 82.27,50.57 82.27,52.12 81.75,52.64 81.75,56.1 v1(81.28,56.58)
ETH1_RXCTL_M0: length 70.2
  TOP w0.102: CN5.6 v1(76.72,11.18) ; R68.1 v1(80.26,56.58) R69.1
  ART03 w0.097: v1(80.26,56.58) 80.78,57.1 81.48,57.1 82.25,56.34 82.25,52.84 82.71,52.38 82.71,50.27 82.84,50.13 82.84,49.17 84.19,47.83 85.34,47.83 85.92,47.25 85.92,44.75 85.42,44.25 85.42,37.52 85.61,37.33 85.92,37.33 86.08,37.17 86.08,36.85 85.92,36.69 85.61,36.69 85.45,36.53 85.45,34.01 85.67,33.78 86.47,33.78 86.79,33.46 86.79,28.75 86.23,28.19 86.23,27.91 86.42,27.72 86.94,27.72 87.1,27.56 87.1,27.24 86.94,27.08 86.37,27.08 86.23,26.95 86.23,26.24 86.39,26.08 87.27,26.08 87.43,25.92 87.43,25.6 87.27,25.44 86.39,25.44 86.23,25.28 86.23,24.96 86.39,24.8 87.27,24.8 87.43,24.64 87.43,24.32 87.27,24.16 86.39,24.16 86.23,24 86.23,23.68 86.39,23.52 87.27,23.52 87.43,23.36 87.43,23.04 87.27,22.88 86.39,22.88 86.23,22.72 86.23,22.4 86.39,22.24 87.27,22.24 87.43,22.08 87.43,21.76 87.27,21.6 86.39,21.6 86.23,21.44 86.23,20.6 85.45,19.81 85.45,19.15 82.37,16.08 78.44,16.08 76.72,14.37 v1(76.72,11.18)
ETH1_RXD0_M0: length 71.3
  TOP w0.102: R57.2 v1(79.25,56.58) R60.1 ; v1(77.22,13.02) 77.12,12.92 CN5.8
  ART03 w0.097: v1(77.22,13.02) 77.22,14.13 78.64,15.54 82.55,15.54 86.23,19.23 86.23,19.74 88.04,21.54 88.04,27.79 87.88,27.95 87.51,27.95 87.35,28.11 87.35,28.43 87.51,28.59 87.88,28.59 88.04,28.75 88.04,29.07 87.88,29.23 87.56,29.23 87.4,29.39 87.4,29.71 87.56,29.87 87.88,29.87 88.04,30.03 88.04,30.35 87.88,30.51 87.56,30.51 87.4,30.67 87.4,30.99 87.56,31.15 87.88,31.15 88.04,31.31 88.04,31.63 87.88,31.79 87.56,31.79 87.4,31.95 87.4,32.27 87.56,32.43 87.88,32.43 88.04,32.59 88.04,32.91 87.88,33.07 87.56,33.07 87.4,33.23 87.4,33.55 87.56,33.71 87.88,33.71 88.04,33.87 88.04,34.17 87.82,34.39 86.23,34.39 86,34.62 86,35.76 86.84,36.6 86.84,37.77 86.67,37.94 86.15,37.94 85.98,38.1 85.98,38.33 86.15,38.5 86.62,38.5 86.79,38.67 86.79,38.91 86.62,39.08 86.15,39.08 85.98,39.25 85.98,39.49 86.15,39.66 86.62,39.66 86.79,39.83 86.79,40.07 86.62,40.24 86.15,40.24 85.98,40.41 85.98,43.59 86.18,43.79 87.12,43.79 87.33,43.99 87.33,47.85 86.72,48.46 85.11,48.46 84.42,49.15 83.6,49.15 83.44,49.31 83.44,50.14 83.13,50.44 83.13,56.06 81.56,57.63 80.3,57.63 v1(79.25,56.58)
ETH1_RXD1_M0: length 70.6
  TOP w0.102: CN5.10 77.52,11.38 v1(77.72,11.18) ; R61.1 v1(78.23,56.58) R58.2
  ART03 w0.097: v1(77.72,11.18) 77.72,13.89 78.88,15.05 82.69,15.05 86.59,18.95 87.01,18.95 87.2,19.14 87.2,19.76 88.6,21.16 88.6,34.37 87.91,35.05 87.4,35.05 87.2,35.26 87.2,36.04 87.45,36.3 88.33,36.3 88.49,36.46 88.49,36.79 88.33,36.95 87.61,36.95 87.45,37.11 87.45,37.43 87.61,37.59 88.33,37.59 88.44,37.7 88.44,38.25 88.29,38.4 87.66,38.4 87.43,38.63 87.43,40.73 87.26,40.9 86.76,40.9 86.59,41.07 86.59,41.31 86.76,41.48 87.26,41.48 87.43,41.65 87.43,42.37 87.68,42.62 88.39,42.62 88.54,42.77 88.54,47.55 87.17,48.92 85.83,48.92 84.11,50.63 84.11,53.4 83.72,53.8 83.72,56.11 81.64,58.19 79.84,58.19 v1(78.23,56.58)
ETH1_RXD2_M0: length 71.2
  TOP w0.102: R63.1 v1(77.22,56.58) R65.1 ; v1(78.22,13.02) 77.92,12.72 CN5.12
  ART03 w0.097: v1(77.22,56.58) 79.44,58.8 81.66,58.8 83.85,56.62 84.15,56.62 84.56,56.21 84.56,53.89 85.04,53.42 85.04,50.55 86.11,49.48 87.38,49.48 89.08,47.78 89.08,42.07 88.91,41.9 88.13,41.9 87.96,41.73 87.96,41.49 88.13,41.32 88.91,41.32 89.08,41.15 89.08,40.91 88.91,40.74 88.13,40.74 87.96,40.57 87.96,40.33 88.13,40.16 88.91,40.16 89.08,39.99 89.08,39.75 88.91,39.58 88.13,39.58 87.96,39.41 87.96,39.17 88.13,39 88.91,39 89.08,38.83 89.08,36.2 88.6,35.71 88.6,35.2 89.15,34.65 89.15,20.68 88.29,19.81 88.29,18.49 87.88,18.08 86.39,18.08 82.85,14.55 79.15,14.55 78.22,13.63 v1(78.22,13.02)
ETH1_RXD3_M0: length 69.8
  TOP w0.102: v1(78.72,11.18) 78.5,11.18 78.32,11.35 CN5.14 ; R64.1 v1(76.2,56.58) R66.1
  ART03 w0.097: v1(76.2,56.58) 78.93,59.31 81.89,59.31 83.39,57.81 84.35,57.81 85.06,57.1 85.06,54.33 86.11,53.28 86.11,50.37 86.52,49.96 87.66,49.96 89.99,47.62 89.99,44.91 89.74,44.65 89.74,20.52 89.15,19.94 89.15,18.69 88.06,17.6 86.61,17.6 83.04,14.03 79.33,14.03 78.72,13.42 v1(78.72,11.18)
ETH1_TXCLK_M0: length 62.7
  TOP w0.102: U8.20 76.43,61.07 75.82,60.45 75.82,59.78 75.52,59.49 75.52,59.49 75.52,59.48 74.82,59.48 v1(74.31,58.97) ; CN5.3 76.32,17.1 75.72,17.7 v1(75.72,18.51)
  ART03 w0.097: v1(74.31,58.97) 74.31,58.56 75.17,57.7 75.17,56.13 76.02,55.27 77.72,55.27 78.94,54.05 78.94,53.14 80.06,52.02 80.06,50.5 80.71,49.85 80.71,47.94 80.98,47.68 80.98,45.24 80.7,44.96 79.58,44.96 79.35,44.73 79.35,43.89 79.63,43.61 82.25,43.61 83.03,42.82 83.03,21.01 79.95,17.92 76.3,17.92 v1(75.72,18.51)
ETH1_TXCTL_M0: length 63.3
  TOP w0.102: v1(75.72,19.51) 76.23,19 76.23,17.86 76.72,17.36 CN5.5 ; v1(75.31,59.97) 75.31,60.58 76.2,61.47 U8.19
  ART03 w0.097: v1(75.31,59.97) 74.9,59.56 74.9,58.8 75.66,58.05 75.66,56.41 76.18,55.88 77.75,55.88 79.39,54.24 79.39,53.35 80.52,52.22 80.52,50.65 81.15,50.01 81.15,48.13 81.76,47.52 81.76,47.07 81.41,46.71 81.41,45.29 83.59,43.1 83.59,20.8 80.22,17.43 76.14,17.43 75.23,18.34 75.23,19.02 v1(75.72,19.51)
ETH1_TXD0_M0: length 62.2
  TOP w0.102: U8.18 76.01,61.87 75.49,61.34 75.22,61.34 74.88,61 74.88,60.54 v1(74.31,59.97) ; v1(78.32,19.15) CN5.13
  ART03 w0.097: v1(78.32,19.15) 78.68,19.51 79.88,19.51 81.88,21.5 81.88,41.72 81.48,42.11 79.58,42.11 78.21,43.48 76.23,43.48 75.39,44.32 75.39,50.06 75.97,50.65 75.97,53.7 74.24,55.43 74.24,57.11 73.17,58.18 73.17,61.27 73.36,61.46 74.63,61.46 74.86,61.23 74.86,60.2 74.63,59.97 v1(74.31,59.97)
ETH1_TXD1_M0: length 62.6
  TOP w0.102: v1(74.31,60.97) 74.31,61.15 75.03,61.87 75.49,61.87 75.88,62.27 U8.17 ; v1(77.72,18.51) 77.92,18.31 CN5.11
  ART03 w0.097: v1(74.31,60.97) 73.66,60.32 73.66,58.42 74.68,57.4 74.68,55.75 75.77,54.66 77.4,54.66 77.72,54.34 77.72,52.37 78.03,52.07 78.03,50.62 77.67,50.27 76.2,50.27 75.87,49.94 75.87,44.65 76.43,44.09 78.33,44.09 79.73,42.7 82.12,42.7 82.44,42.37 82.44,21.25 80.19,19 78.84,19 78.35,18.51 v1(77.72,18.51)
ETH1_TXD2_M0: length 62.2
  TOP w0.102: CN5.9 77.52,17.85 77.23,18.15 77.23,19 v1(76.72,19.51) ; U8.16 75.75,62.67 75.44,62.36 74.69,62.36 v1(74.31,61.97)
  ART03 w0.097: v1(76.72,19.51) 77.23,20.02 79.63,20.02 81.41,21.79 81.41,41.35 81.23,41.53 80.9,41.53 80.73,41.36 80.73,40.94 80.56,40.77 80.32,40.77 80.16,40.94 80.16,41.36 79.99,41.53 79.25,41.53 77.73,43.05 75.8,43.05 74.96,43.89 74.96,54.08 73.77,55.26 73.77,56.81 72.68,57.9 72.68,61.65 73,61.97 v1(74.31,61.97)
ETH1_TXD3_M0: length 62.4
  TOP w0.102: CN5.7 77.12,17.59 76.72,17.99 v1(76.72,18.51) ; U8.15 75.4,63.07 v1(75.31,62.97)
  ART03 w0.097: v1(76.72,18.51) 76.55,18.51 76.23,18.83 76.23,20.19 76.55,20.51 79.51,20.51 80.77,21.77 80.77,39.14 77.29,42.62 75.43,42.62 74.52,43.53 74.52,53.87 73.33,55.07 73.33,56.56 72.19,57.7 72.19,62.98 72.35,63.14 72.81,63.14 72.97,62.98 72.97,62.64 73.13,62.48 74.82,62.48 v1(75.31,62.97)
FAN_CTRL: length 81.3
  TOP w0.152: v1(87.72,11.18) 87.92,11.38 CN5.62 ; R13.1 v1(54.23,54.86)
  ART03 w0.152: v1(54.23,54.86) 52.1,52.73 52.1,50.11 50.27,48.29 50.27,22.73 v1(50.5,22.5)
  BOTTOM w0.152: v1(87.72,11.18) 87.72,13.27 87.07,13.92 85.42,13.92 83.97,15.37 82.35,15.37 81.03,16.69 81.03,19.15 79.78,20.4 76.76,20.4 76.38,20.02 74.24,20.02 73.53,19.3 66.34,19.3 63.47,22.17 50.83,22.17 v1(50.5,22.5)
FUSB302_INT: length 51.5
  TOP w0.152: CN2.39 59.92,44.86 59.44,44.38 59.44,42.93 59.14,42.63 56.65,42.63 55.88,41.86 40.54,41.86 v1(40.17,42.23)
  ART03 w0.152: v1(40.17,42.23) 38.25,44.15 38.25,52.48 40.28,54.51 40.28,61.32 40.97,62 v1(40.97,64.41)
  BOTTOM w0.152: U11.5 39.19,64.64 39.42,64.41 v1(40.97,64.41) 41.69,64.41 41.92,64.64 R109.2
HDMI_5V: length 5.7
  BOTTOM w0.508: J33.18 99.44,71.5 D48.1
HDMI_TX_CEC_M0: length 15.2
  TOP w0.152: CN3.46 84.72,49.52 84.81,49.61 84.81,50.22 84.68,50.34 84.68,51.62 v1(84.52,51.79)
  BOTTOM w0.152: R152.1 87.38,61.54 87.66,61.26 87.66,59.08 85.64,57.06 85.64,54.7 84.52,53.59 v1(84.52,51.79)
HDMI_TX_CEC_PORT: length 18.4
  BOTTOM w0.152: Q10.3 86.36,68.63 87.35,69.62 91.97,69.62 93.37,71.02 93.37,73.69 94.13,74.45 95.8,74.45 96.16,74.81 D43.2 98.19,74.93 J33.13
HDMI_TX_D0N: length 87.6
  TOP w0.084: CN2.59 63.92,45.48 arc(63.93,45.42) 63.97,45.37 63.98,45.36 arc(64.01,45.31) 64.02,45.25 64.02,45.13 arc(63.99,44.99) 63.91,44.86 63.61,44.56 arc(63.49,44.38) 63.45,44.18 63.45,44.16 arc(63.49,43.96) 63.61,43.79 63.8,43.59 arc(63.89,43.46) 63.92,43.3 v1(63.92,43.11) ; v1(96.23,60.4) 95.99,60.4 arc(95.94,60.4) 95.9,60.43 95.89,60.44 arc(95.87,60.48) 95.86,60.53 95.86,61.92 arc(95.89,62.07) 95.97,62.2 C221.1
  BOTTOM w0.084: v1(96.23,60.4) 95.97,60.4 arc(95.84,60.45) 95.78,60.58 95.78,60.95 arc(95.83,61.21) 95.98,61.44 96.21,61.66 arc(96.42,61.8) 96.67,61.85 105.07,61.85 arc(105.64,61.74) 106.12,61.42 107.82,59.72 arc(108.14,59.24) 108.25,58.67 108.25,45.9 arc(108.14,45.33) 107.82,44.86 99.69,36.72 arc(99.21,36.4) 98.65,36.29 75.34,36.29 arc(74.92,36.38) 74.56,36.61 74.32,36.86 arc(74.1,37.01) 73.83,37.06 67.8,37.06 arc(67.23,37.17) 66.75,37.49 64.59,39.65 arc(64.42,39.9) 64.36,40.2 64.36,40.46 arc(64.39,40.51) 64.44,40.54 arc(64.49,40.56) 64.52,40.61 64.52,40.79 arc(64.49,40.85) 64.44,40.87 arc(64.39,40.89) 64.36,40.95 64.36,41.13 arc(64.39,41.18) 64.44,41.21 arc(64.49,41.23) 64.52,41.28 64.52,41.46 arc(64.49,41.52) 64.44,41.54 arc(64.39,41.56) 64.36,41.62 64.36,41.69 arc(64.34,41.82) 64.27,41.93 63.79,42.4 arc(63.69,42.55) 63.65,42.74 63.65,42.95 arc(63.7,43.07) 63.81,43.11 v1(63.92,43.11)
HDMI_TX_D0N_PORT: length 16.7
  TOP w0.084: C221.2 95.92,63.84 arc(95.87,63.91) 95.85,63.99 95.85,64.01 arc(95.87,64.09) 95.92,64.16 R233.1 95.92,64.87 arc(95.83,65) 95.8,65.15 95.8,65.47 arc(95.83,65.59) 95.89,65.69 D50.2 95.99,65.97 arc(95.97,66.1) 95.9,66.2 95.89,66.21 arc(95.82,66.31) 95.79,66.43 95.79,66.52 arc(95.82,66.67) 95.91,66.8 97.37,68.26 arc(97.49,68.44) 97.54,68.66 97.54,75.58 arc(97.56,75.63) 97.61,75.65 arc(97.67,75.67) 97.69,75.73 97.69,75.91 arc(97.67,75.96) 97.61,75.99 arc(97.56,76.01) 97.54,76.06 97.54,76.25 arc(97.56,76.3) 97.61,76.32 arc(97.67,76.34) 97.69,76.4 97.69,76.58 arc(97.67,76.64) 97.61,76.66 arc(97.56,76.68) 97.54,76.73 97.54,76.83 arc(97.56,76.97) 97.64,77.09 97.87,77.32 98.27,77.32 arc(98.5,77.23) 98.59,77 J33.9
HDMI_TX_D0P: length 87.9
  TOP w0.084: CN2.61 64.32,45.48 arc(64.31,45.42) 64.28,45.37 64.27,45.36 arc(64.23,45.31) 64.22,45.25 64.22,45.13 arc(64.18,44.91) 64.05,44.72 63.74,44.41 arc(63.72,44.35) 63.74,44.29 v1(63.92,44.11) ; C220.1 95.54,62.2 arc(95.63,62.07) 95.66,61.92 95.66,60.88 arc(95.66,60.85) 95.65,60.82 arc(95.61,60.7) 95.54,60.6 v1(95.34,60.4)
  BOTTOM w0.084: v1(63.92,44.11) 63.92,43.94 arc(63.89,43.79) 63.81,43.67 63.57,43.43 arc(63.48,43.29) 63.45,43.14 63.45,42.7 arc(63.49,42.48) 63.62,42.3 64.13,41.79 arc(64.16,41.74) 64.17,41.69 64.17,40.2 arc(64.24,39.83) 64.45,39.51 66.61,37.35 arc(67.15,36.99) 67.8,36.86 73.83,36.86 arc(74.02,36.82) 74.18,36.72 74.42,36.47 arc(74.84,36.19) 75.34,36.09 98.65,36.09 arc(99.29,36.22) 99.83,36.58 107.96,44.71 arc(108.33,45.26) 108.45,45.9 108.45,58.67 arc(108.33,59.31) 107.96,59.86 106.26,61.56 arc(105.71,61.92) 105.07,62.05 96.67,62.05 arc(96.34,61.99) 96.07,61.8 95.84,61.58 arc(95.65,61.29) 95.58,60.95 95.58,60.8 arc(95.55,60.65) 95.47,60.52 v1(95.34,60.4)
HDMI_TX_D0P_PORT: length 16.4
  TOP w0.084: J33.7 98.22,77.63 arc(98.1,77.55) 97.96,77.52 97.79,77.52 97.5,77.23 arc(97.38,77.05) 97.34,76.83 97.34,68.66 arc(97.31,68.52) 97.23,68.4 95.77,66.94 arc(95.64,66.75) 95.6,66.52 95.6,66.43 arc(95.57,66.31) 95.5,66.21 95.49,66.2 arc(95.42,66.1) 95.4,65.97 D49.2 95.51,65.68 arc(95.58,65.57) 95.61,65.44 95.61,65.13 arc(95.56,64.9) 95.43,64.7 R234.1 95.59,64.17 arc(95.64,64.09) 95.66,64.01 95.66,63.99 arc(95.64,63.91) 95.59,63.83 C220.2
HDMI_TX_D1N: length 79
  TOP w0.084: C219.1 105.57,62.2 arc(105.66,62.07) 105.69,61.92 105.69,60.62 arc(105.68,60.54) 105.63,60.47 105.62,60.45 arc(105.55,60.41) 105.47,60.4 v1(105.37,60.4) ; v1(64.92,43.11) 64.92,43.29 arc(64.89,43.45) 64.81,43.58 64.55,43.83 arc(64.47,43.95) 64.44,44.1 64.44,44.12 arc(64.47,44.26) 64.55,44.38 64.64,44.47 arc(64.78,44.68) 64.82,44.92 64.82,45.25 arc(64.81,45.31) 64.78,45.36 64.77,45.37 arc(64.73,45.42) 64.72,45.48 CN2.63
  BOTTOM w0.084: v1(105.37,60.4) 105.67,60.4 arc(105.76,60.36) 105.79,60.27 105.79,59.92 arc(105.73,59.77) 105.58,59.71 104.24,59.71 arc(103.84,59.3) 104.24,58.9 106.86,58.9 arc(107.01,58.84) 107.07,58.69 107.07,58.48 arc(107,58.34) 106.86,58.27 105.28,58.27 arc(104.88,57.87) 105.28,57.46 105.59,57.46 arc(106.63,57.03) 107.07,55.98 107.07,45.97 arc(106.95,45.41) 106.63,44.93 99.17,37.47 arc(98.69,37.15) 98.13,37.03 76.02,37.03 arc(75.48,37.14) 75.03,37.44 74.96,37.51 arc(74.45,37.85) 73.84,37.97 68.2,37.97 arc(67.64,38.09) 67.16,38.41 65.45,40.12 arc(65.36,40.25) 65.33,40.4 65.33,40.52 arc(65.35,40.57) 65.39,40.58 arc(65.44,40.6) 65.46,40.65 65.46,40.86 arc(65.44,40.9) 65.39,40.92 arc(65.35,40.94) 65.33,40.98 65.33,41.19 arc(65.35,41.24) 65.39,41.26 arc(65.44,41.27) 65.46,41.32 65.46,41.53 arc(65.44,41.57) 65.39,41.59 arc(65.35,41.61) 65.33,41.65 65.33,41.73 arc(65.3,41.85) 65.24,41.96 64.82,42.37 arc(64.71,42.54) 64.67,42.75 64.67,42.99 arc(64.71,43.08) 64.8,43.11 v1(64.92,43.11)
HDMI_TX_D1N_PORT: length 25.1
  TOP w0.084: C219.2 105.62,63.83 arc(105.67,63.91) 105.69,63.99 105.69,64.01 arc(105.67,64.09) 105.62,64.17 R231.1 105.64,64.88 arc(105.72,65.01) 105.76,65.16 105.76,65.46 arc(105.73,65.58) 105.66,65.68 D56.2 105.56,65.97 arc(105.58,66.1) 105.65,66.2 105.66,66.21 arc(105.73,66.31) 105.76,66.43 105.76,78.13 arc(105.73,78.26) 105.66,78.36 105.06,78.96 arc(104.95,79.04) 104.82,79.06 103.5,79.06 arc(103.35,79) 103.29,78.85 103.29,78.44 arc(102.88,78.03) 102.48,78.44 102.48,78.85 arc(102.27,79.06) 102.06,78.85 102.06,78.44 arc(101.65,78.03) 101.24,78.44 101.24,78.85 arc(101.18,79) 101.03,79.06 100.24,79.06 arc(100.08,79.03) 99.95,78.94 J33.6
HDMI_TX_D1P: length 78.7
  TOP w0.084: C218.1 106.01,62.2 arc(105.92,62.07) 105.89,61.92 105.89,60.82 arc(105.92,60.67) 106.01,60.54 106.12,60.43 arc(106.16,60.4) 106.2,60.4 v1(106.26,60.4) ; CN2.65 65.12,45.48 arc(65.11,45.42) 65.08,45.37 65.07,45.36 arc(65.03,45.31) 65.02,45.25 65.02,44.61 arc(65.01,44.55) 64.98,44.51 64.97,44.49 arc(64.93,44.45) 64.92,44.39 v1(64.92,44.11)
  BOTTOM w0.084: v1(106.26,60.4) 106.12,60.25 arc(106.02,60.11) 105.99,59.94 105.99,59.92 arc(105.87,59.63) 105.58,59.51 104.24,59.51 arc(104.03,59.3) 104.24,59.1 106.86,59.1 arc(107.15,58.98) 107.26,58.69 107.26,58.48 arc(107.14,58.2) 106.86,58.08 105.28,58.08 arc(105.07,57.87) 105.28,57.66 105.59,57.66 arc(106.77,57.17) 107.26,55.98 107.26,45.97 arc(107.14,45.33) 106.77,44.79 99.31,37.33 arc(98.77,36.96) 98.13,36.84 76.02,36.84 arc(75.41,36.96) 74.89,37.3 74.82,37.37 arc(74.37,37.67) 73.84,37.77 68.2,37.77 arc(67.56,37.9) 67.02,38.27 65.31,39.98 arc(65.18,40.17) 65.13,40.4 65.13,41.73 arc(65.12,41.78) 65.1,41.82 64.68,42.23 arc(64.53,42.47) 64.47,42.75 64.47,43.16 arc(64.5,43.3) 64.58,43.42 64.81,43.65 arc(64.89,43.78) 64.92,43.93 v1(64.92,44.11)
HDMI_TX_D1P_PORT: length 25.4
  TOP w0.084: J33.4 99.95,79.38 arc(100.08,79.29) 100.24,79.26 101.03,79.26 arc(101.32,79.14) 101.44,78.85 101.44,78.44 arc(101.65,78.23) 101.86,78.44 101.86,78.85 arc(102.27,79.26) 102.67,78.85 102.67,78.44 arc(102.88,78.23) 103.09,78.44 103.09,78.85 arc(103.21,79.14) 103.5,79.26 104.82,79.26 arc(105.03,79.22) 105.2,79.1 105.8,78.5 arc(105.91,78.33) 105.95,78.13 105.95,66.43 arc(105.98,66.31) 106.05,66.21 106.06,66.2 arc(106.13,66.1) 106.15,65.97 D55.2 106.05,65.68 arc(105.98,65.58) 105.95,65.46 105.95,65.04 arc(105.98,64.88) 106.07,64.75 R232.1 105.95,64.16 arc(105.9,64.09) 105.89,64.01 105.89,63.99 arc(105.9,63.91) 105.95,63.84 C218.2
HDMI_TX_D2N: length 81.9
  TOP w0.084: C217.1 91.82,62.11 arc(91.8,62.08) 91.79,62.05 91.79,59.68 arc(91.82,59.55) 91.89,59.44 91.92,59.41 arc(92.01,59.38) 92.09,59.41 v1(92.11,59.43) ; CN2.67 65.52,45.48 arc(65.53,45.42) 65.57,45.37 65.58,45.36 arc(65.61,45.31) 65.62,45.25 65.62,44.58 arc(65.6,44.47) 65.55,44.39 65.53,44.38 arc(65.48,44.29) 65.46,44.19 65.46,44.11 arc(65.49,43.95) 65.58,43.82 65.8,43.6 arc(65.89,43.46) 65.92,43.3 v1(65.92,43.11)
  BOTTOM w0.084: v1(92.11,59.43) 91.85,59.43 arc(91.78,59.44) 91.73,59.48 91.72,59.49 arc(91.68,59.55) 91.67,59.61 91.67,59.87 arc(91.69,59.98) 91.75,60.08 91.77,60.09 arc(91.86,60.16) 91.97,60.18 92.29,60.18 arc(92.67,60.1) 93,59.88 93.4,59.48 arc(93.53,59.39) 93.68,59.36 96.72,59.36 arc(97.36,59.49) 97.91,59.86 98.02,59.97 arc(98.5,60.29) 99.06,60.4 102.18,60.4 arc(102.69,60.19) 102.9,59.69 102.9,59.37 arc(103.02,58.73) 103.39,58.18 103.53,58.04 arc(103.85,57.56) 103.96,56.99 103.96,56.6 arc(104.09,55.96) 104.45,55.41 104.95,54.92 arc(105.27,54.44) 105.38,53.87 105.38,45.9 arc(105.27,45.33) 104.95,44.86 98.32,38.23 arc(97.85,37.91) 97.28,37.8 76.63,37.8 arc(76.07,37.91) 75.59,38.23 75.4,38.42 arc(74.85,38.79) 74.21,38.91 68.18,38.91 arc(67.82,38.98) 67.52,39.19 67.29,39.42 arc(67.26,39.48) 67.29,39.53 arc(67.31,39.59) 67.29,39.65 67.16,39.77 arc(67.11,39.79) 67.05,39.77 arc(66.99,39.75) 66.94,39.77 66.81,39.89 arc(66.79,39.95) 66.81,40.01 arc(66.84,40.06) 66.81,40.12 66.69,40.24 arc(66.63,40.27) 66.57,40.24 arc(66.52,40.22) 66.46,40.24 66.39,40.31 arc(66.32,40.42) 66.29,40.55 66.29,40.64 arc(66.32,40.69) 66.37,40.71 arc(66.42,40.74) 66.45,40.79 66.45,40.97 arc(66.42,41.03) 66.37,41.05 arc(66.32,41.07) 66.29,41.12 66.29,41.31 arc(66.32,41.36) 66.37,41.38 arc(66.42,41.41) 66.45,41.46 66.45,41.64 arc(66.42,41.7) 66.37,41.72 arc(66.32,41.74) 66.29,41.8 66.29,41.87 arc(66.27,42) 66.2,42.1 65.73,42.57 arc(65.66,42.68) 65.63,42.8 65.63,42.96 arc(65.68,43.07) 65.79,43.11 v1(65.92,43.11)
