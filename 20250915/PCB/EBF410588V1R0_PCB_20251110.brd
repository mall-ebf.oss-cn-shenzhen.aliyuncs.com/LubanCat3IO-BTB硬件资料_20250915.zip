# Allegro board EBF410588V1R0_PCB_20251110.brd (continued)
## Nets (continued)
3V3_OUT: C183.1 C185.1 J23.5 U31.1(OUT)
3V3_WLAN: C141.1 C142.1 Q11.3 U22.8
5V_OUT: C186.1 C187.1 J23.3 U32.1(OUT)
12V: C3.1 C4.1 C5.1 C6.1 C7.1 C12.1 C15.1 C162.1 C163.1 C180.1 F1.2 Q15.3 R8.2 R192.1 R219.1 R221.1 U1.3(VIN) U2.3(VIN) U26.3(VIN)
12V_OUT: C181.1 C182.1 J23.1 Q16.3
GND: C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C72.2 C73.2 C77.2 C78.2 C79.2 C80.2 C83.2 C84.2 C85.2 C87.1 C88.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C103.2 C104.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C141.2 C142.2 C145.2 C146.2 C148.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C162.2 C163.2 C165.2 C166.2 C167.2 C168.2 C169.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C212.1 C213.2 C214.2 C215.2 C226.2 CN1.2 CN1.3 CN2.1 CN2.2 CN2.8 CN2.13 CN2.18 CN2.23 CN2.30 CN2.31 CN2.32 CN2.34 CN2.35 CN2.36 CN2.38 CN2.40 CN2.42 CN2.51 CN2.52 CN2.53 CN2.57 CN2.66 CN2.79 CN2.80 CN3.1 CN3.2 CN3.23 CN3.24 CN3.29 CN3.34 CN3.44 CN3.51 CN3.61 CN3.62 CN3.71 CN3.77 CN3.79 CN3.80 CN4.9 CN4.10 CN4.11 CN4.12 CN4.13 CN4.14 CN4.19 CN4.20 CN4.25 CN4.26 CN4.31 CN4.32 CN4.41 CN4.42 CN4.48 CN4.54 CN4.55 CN4.68 CN4.69 CN4.81 CN4.82 CN4.83 CN4.84 CN5.1 CN5.2 CN5.15 CN5.16 CN5.19 CN5.20 CN5.33 CN5.34 CN5.37 CN5.44 CN5.51 CN5.56 CN5.63 CN5.72 CN5.75 CN5.81 CN5.82 CN5.83 CN5.84 D1.2 D2.1 D3.1 D4.1 D5.1 D6.1 D7.1 D8.1 D10.1 D11.1 D12.1 D13.1 D14.1 D15.1 D16.1 D17.1 D19.1 D20.1 D21.1 D22.1 D23.1 D24.1 D25.2 D26.1 D27.1 D28.1 D29.1 D30.2 D31.1 D32.2 D33.2 D34.1 D35.1 D37.1 D38.1 D39.1 D40.1 D43.1 D44.1 D45.1 D46.1 D47.2 D48.2 D49.1 D50.1 D51.1 D52.1 D53.1 D54.1 D55.1 D56.1 D57.2 D58.1 DN1.3 DN2.3 J1.2 J1.3 J2.2 J4.6(VSS) J4.10 J4.11 J4.12 J4.13 J5.2 J6.10 J7.10 J10.A1 J10.A12 J10.B1 J10.B12 J11.4 J11.7 J11.13 J11.16 J12.4 J12.10 J13.6 J13.7 J13.8 J13.16 J13.19 J13.22 J13.25 J13.28 J13.31 J13.32(SH2) J14.4 J14.18 J14.21 J14.23 J14.24 J14.25 J14.26(SH2) J15.4 J15.18 J15.21 J15.23 J15.24 J15.25 J15.26(SH2) J16.4 J16.18 J16.21 J16.23 J16.24 J16.25 J16.26(SH2) J17.4 J17.18 J17.21 J17.23 J17.24 J17.25 J17.26(SH2) J18.4 J18.18 J18.21 J18.23 J18.24 J18.25 J18.26(SH2) J19.5 J19.8 J19.9 J19.10 J19.11 J20.4 J20.9 J20.15 J20.18 J20.21 J20.26 J20.27 J20.29 J20.34 J20.35 J20.37 J20.40 J20.43 J20.50 J20.53 J20.54 J21.3 J23.2 J23.4 J23.6 J24.2 J24.5 J25.4 J26.4 J30.6 J32.6 J32.9 J32.14 J32.18 J33.2 J33.5 J33.8 J33.11 J33.17 L2.2 L10.2 L11.2 L12.2 L27.1 LED1.1(CATHODE) Q2.2(EMITTER) Q3.2(SOURCE) Q8.2(SOURCE) Q9.2(SOURCE) Q12.2(SOURCE) Q17.2(EMITTER) Q18.2(SOURCE) Q19.2(SOURCE) Q20.2(SOURCE) Q21.2(SOURCE) R2.2 R5.2 R7.2 R9.2 R14.2 R16.2 R38.2 R43.2 R44.2 R45.2 R50.2 R51.2 R54.2 R55.2 R56.2 R62.2 R65.2 R66.2 R69.2 R74.2 R75.2 R78.2 R79.2 R80.2 R85.1 R86.2 R90.2 R92.2 R94.2 R100.2 R101.2 R104.1 R120.2 R123.2 R124.2 R125.2 R133.2 R135.2 R137.1 R151.2 R154.2 R161.2 R165.2 R176.2 R178.2 R194.2 R196.2 R197.2 R212.2 R214.2 R217.2 R218.2 R226.2 R242.2 R243.2 SS5.1(NC_1) SS6.1(NC_1) SS7.1(NC_1) SS8.1(NC_1) SS9.1(NC_1) SS10.1(NC_1) SW1.1 SW1.3(GND1) SW2.1 SW2.3(GND1) SW3.1 SW3.3(GND1) U1.1 U2.1 U3.2 U4.1 U4.4 U5.4 U6.1 U7.41 U8.41 U9.4 U9.13 U9.18 U9.29 U10.7 U10.9 U11.8 U11.9 U11.15 U12.2 U13.2 U14.3 U14.8 U15.3 U15.8 U16.3 U16.8 U17.3 U17.8 U18.3 U18.8 U19.10 U19.24 U19.39 U20.2 U22.1 U22.5 U24.2 U25.2 U26.1 U27.2 U28.1(\\O\E) U28.3 U29.1(\\O\E) U29.3 U31.2 U32.2 U33.15 U34.2 U34.8 U35.2 U35.8 U36.5 U37.5 U38.7 U38.9 Y2.2 Y2.4(GND2) Y3.2 Y3.4(GND2) Y4.2 Y4.4(GND2)
VBUS5V0_TYPEC: C103.1 C104.1 J10.A4 J10.A9 J10.B4 J10.B9(VBUS4) U11.2 U12.1(OUT)
VCC3V3_RTC_S5: C31.1 D9.2 R241.1 U6.2(VOUT)
VCC5V0_SYS_S5: C11.2 C13.1 C14.1 C32.1 CN4.1 CN4.2 CN4.3 CN4.4 CN4.5 CN4.6 CN4.7 CN4.8 L3.2 R4.1 R6.2 R198.2 U6.3
VCC5V0_USB20_HOST: C111.1 C119.1 C128.1 C129.1 J11.10(VBUS) J12.1 J12.7(VBUS) U20.1(OUT)
VCC5V0_USB30_HOST: C107.1 C108.1 J11.1 U13.1(OUT)
VCC_1V8_S3: C133.1 C134.1 CN4.22 CN4.23 CN4.24 D58.2 J30.1 R28.1 R156.1 R158.1 R159.1
VCC_3V3_S0: C18.1 C19.1 C20.1 C21.1 CN4.15 CN4.16 CN4.17 CN4.18 J4.4 U3.5
VCC_RTC: C26.1 D9.3 R32.1 R157.1 U5.8
VCCA1V8_PLDO2_S0: CN4.21 R15.1
VDD_3V3: C16.1 C17.1 C33.1 C34.1 C35.1 C49.1 C50.1 C51.1 C91.1 C92.1 C143.1 C176.1 C177.1 C189.1 C196.1 J32.1 J32.17 L5.1 L7.1 L8.1 L9.1 L15.2 L16.1 L17.1 Q6.1 Q7.1 Q11.2(SOURCE) R3.1 R12.1 R21.1 R22.1 R33.1 R34.1 R35.1 R46.1 R47.1 R48.1 R53.1 R57.1 R58.1 R59.1 R70.1 R71.1 R72.1 R77.1 R82.2 R87.1 R91.1 R97.2 R103.1 R109.1 R127.1 R136.1 R139.1 R141.1 R142.1 R144.1 R145.1 R146.1 R148.1 R150.1 R160.1 R162.1 R163.1 R188.1 R189.1 R190.1 R235.1 R236.1 R237.1 R238.1 R239.1 R240.1 U3.1(OUT) U7.28 U7.29 U8.28 U8.29 U11.3 U11.4(VDD2) U11.12 U11.13 U25.5 U28.5 U29.5 U31.5 U34.5(VIO) U35.5(VIO)
VDD_5V: C2.2 C8.1 C9.1 C93.1 C94.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C190.1 C197.1 D36.2 J32.2 J32.4 L1.2 Q1.2(SOURCE) Q10.1 R1.2 R10.1 R126.1 R140.1 R147.1 R166.1 R167.1 R168.1 R169.1 R170.1 R220.1 R222.1 U12.5 U13.5 U20.5 U24.5 U32.5 U34.3 U35.3
BAT_RTC: C24.1 D9.1 D10.2 J5.1
BM8563_INT: D18.1 Q3.1 R32.2 R157.2 U5.3(\\I\N\T)
BOOT_SARADC_IN0: CN4.29 R27.2
CAM0_PWDN: CN2.7 J14.15
CAM0_RSTN: CN2.5 J14.22
CAM1_PWDN: CN5.71 J15.15
CAM1_RSTN: CN5.69 J15.22
CAM2_PWDN: CN5.73 J16.15
CAM2_RSTN: CN2.3 J16.22
CAM3_PWDN: CN5.65 J18.15
CAM3_RSTN: CN5.67 J18.22
CAM4_PWDN: CN2.9 J17.15
CAM4_RSTN: CN2.11 J17.22
CAN0_H: D57.1 J29.1 R205.1 U34.7
CAN0_L: D47.1 J29.2 R205.2 U34.6
CAN0_RX_M2: CN5.58 U34.4
CAN0_TX_M2: CN5.60 U34.1
CAN1_H: D30.1 J29.3 R206.1 U35.7
CAN1_L: D25.1 J29.4 R206.2 U35.6
CAN1_RX_M3: CN4.62 U35.4
CAN1_TX_M3: CN4.60 U35.1
CTP_INT: CN2.14 J13.11 R144.2
CTP_RST: CN2.16 J13.12 R145.2
DP_TX_AUXN: C106.2 CN3.47
DP_TX_AUXP: C105.2 CN3.49
DSI_VDD3V3: C145.1 C146.1 J13.4 J13.5 U25.1(OUT)
DSI_VDD5V: C138.1 C139.1 J13.1 J13.2 J13.3 U24.1(OUT)
EARPHONE_CTL: CN3.78 R95.2
ETH0_MCLK_M0: CN5.17 R49.1
ETH0_MDC_M0: CN5.48 R48.2 U7.13
ETH0_MDIO_M0: CN5.46 R47.2 U7.14
ETH0_RSTN: CN5.50 D59.1
ETH0_RXCLK_M0: CN5.22 R41.1 R44.1
ETH0_RXCTL_M0: CN5.24 R42.1 R45.1
ETH0_RXD0_M0: CN5.26 R33.2 R37.1
ETH0_RXD1_M0: CN5.28 R34.2 R36.1
ETH0_RXD2_M0: CN5.30 R39.1 R43.1
ETH0_RXD3_M0: CN5.32 R35.2 R40.1
ETH0_TXCLK_M0: CN5.21 U7.20
ETH0_TXCTL_M0: CN5.23 U7.19
ETH0_TXD0_M0: CN5.25 U7.18
ETH0_TXD1_M0: CN5.27 U7.17
ETH0_TXD2_M0: CN5.29 U7.16
ETH0_TXD3_M0: CN5.31 U7.15
ETH1_MCLK_M0: CN5.18 R73.1
ETH1_MDC_M0: CN3.56 R72.2 U8.13
ETH1_MDIO_M0: CN3.58 R71.2 U8.14
ETH1_RSTN: CN3.60 D60.1
ETH1_RXCLK_M0: CN5.4 R59.2 R67.1
ETH1_RXCTL_M0: CN5.6 R68.1 R69.1
ETH1_RXD0_M0: CN5.8 R57.2 R60.1
ETH1_RXD1_M0: CN5.10 R58.2 R61.1
ETH1_RXD2_M0: CN5.12 R63.1 R65.1
ETH1_RXD3_M0: CN5.14 R64.1 R66.1
ETH1_TXCLK_M0: CN5.3 U8.20
ETH1_TXCTL_M0: CN5.5 U8.19
ETH1_TXD0_M0: CN5.13 U8.18
ETH1_TXD1_M0: CN5.11 U8.17
ETH1_TXD2_M0: CN5.9 U8.16
ETH1_TXD3_M0: CN5.7 U8.15
FAN_CTRL: CN5.62 R13.1
FUSB302_INT: CN2.39 R109.2 U11.5
HDMI_5V: C226.1 D36.1 D48.1 J33.18
HDMI_TX_CEC_M0: CN3.46 R152.1
HDMI_TX_CEC_PORT: D43.2 J33.13 Q10.3
HDMI_TX_D0N: C221.1 CN2.59
HDMI_TX_D0N_PORT: C221.2 D50.2 J33.9 R233.1
HDMI_TX_D0P: C220.1 CN2.61
HDMI_TX_D0P_PORT: C220.2 D49.2 J33.7 R234.1
HDMI_TX_D1N: C219.1 CN2.63
HDMI_TX_D1N_PORT: C219.2 D56.2 J33.6 R231.1
HDMI_TX_D1P: C218.1 CN2.65
HDMI_TX_D1P_PORT: C218.2 D55.2 J33.4 R232.1
HDMI_TX_D2N: C217.1 CN2.67
HDMI_TX_D2N_PORT: C217.2 D54.2 J33.3 R229.1
HDMI_TX_D2P: C216.1 CN2.69
HDMI_TX_D2P_PORT: C216.2 D53.2 J33.1 R230.1
HDMI_TX_D3N: C223.1 CN2.71
HDMI_TX_D3N_PORT: C223.2 D52.2 J33.12 R227.1
HDMI_TX_D3P: C222.1 CN2.73
HDMI_TX_D3P_PORT: C222.2 D51.2 J33.10 R228.1
HDMI_TX_EARC+: C224.2 D44.2 J33.14
HDMI_TX_EARC-: C225.2 D31.2 J33.19 R149.2
HDMI_TX_HPDIN_M0: CN3.54 Q8.3 R141.2
HDMI_TX_ON_H: CN3.52 R164.1
HDMI_TX_SBDN: C225.1 CN2.75
HDMI_TX_SBDP: C224.1 CN2.77
HDMI_TX_SCL: CN3.50 Q6.2(SOURCE) R139.2
HDMI_TX_SCL_PORT: D45.2 J33.15 Q6.3 R140.2
HDMI_TX_SDA: CN3.48 Q7.2(SOURCE) R146.2
HDMI_TX_SDA_PORT: D46.2 J33.16 Q7.3 R147.2
HP_BUTTON_DET: C77.1 CN3.74 R83.2 R86.1
HP_PLUG_IN_DET: CN3.76 R88.2
I2C1_SCL_M0: CN2.19
I2C1_SDA_M0: CN2.21
I2C2_SCL_M0: CN2.15 J13.9 R239.2 U11.6
I2C2_SDA_M0: CN2.17 J13.10 R240.2 U11.7
I2C3_SCL_M0: CN5.38 J14.6 R162.2 U5.6 U9.28
I2C3_SDA_M0: CN5.36 J14.5 R160.2 U5.5 U9.27
I2C4_SCL_M2: CN5.80 J15.6 R188.2
I2C4_SDA_M2: CN5.78 J15.5 R163.2
I2C5_SCL_M3: CN5.79 J16.6 R190.2
I2C5_SDA_M3: CN5.77 J16.5 R189.2
I2C7_SCL_M1: CN5.42 J18.6 J32.5 R236.2
I2C7_SDA_M1: CN5.40 J18.5 J32.3 R235.2
I2C8_SCL_M2: CN5.76 J17.6 R238.2
I2C8_SDA_M2: CN5.74 J17.5 R237.2
LCD_BL_PWM: CN2.10 J13.13
LCD_PWR_EN: CN2.45 R153.1
LCD_RST: CN2.12 J13.15
LOUT1: C81.2 U9.12
LOUT2: C86.1 U9.15
MASKROM: C25.1 D11.2 R27.1 SW1.2
MIC1N: C74.2 R85.2
MIC1P: C71.2 R81.2
MIC2N: C76.2 C89.2 P1.2 R101.1
MIC2P: C75.2 C89.1 P1.1(OUT) R99.2
MINIPCIE_3V3: C135.1 C164.2 C165.1 C166.1 C172.1 C173.1 C174.1 C175.1 J20.2 J20.24 J20.39 J20.41 J20.52 L14.2 R172.2 R179.1
MINIPCIE_NWDISABLE: CN2.20 R182.2
MINIPCIE_PWR_EN: CN2.22 R177.1
MIPI_DPHY_CSI0_RX_CLKN: CN3.11 J14.10
MIPI_DPHY_CSI0_RX_CLKP: CN3.13 J14.9
MIPI_DPHY_CSI0_RX_D0N: CN3.3 J14.12
MIPI_DPHY_CSI0_RX_D0P: CN3.5 J14.11
MIPI_DPHY_CSI0_RX_D1N: CN3.7 J14.8
MIPI_DPHY_CSI0_RX_D1P: CN3.9 J14.7
MIPI_DPHY_CSI0_RX_D2N: CN3.15 J14.17
MIPI_DPHY_CSI0_RX_D2P: CN3.17 J14.16
MIPI_DPHY_CSI0_RX_D3N: CN3.19 J14.20
MIPI_DPHY_CSI0_RX_D3P: CN3.21 J14.19
MIPI_DPHY_CSI1_RX_CLKN: CN2.62 J15.10
MIPI_DPHY_CSI1_RX_CLKP: CN2.64 J15.9
MIPI_DPHY_CSI1_RX_D0N: CN2.54 J15.12
MIPI_DPHY_CSI1_RX_D0P: CN2.56 J15.11
MIPI_DPHY_CSI1_RX_D1N: CN2.58 J15.8
MIPI_DPHY_CSI1_RX_D1P: CN2.60 J15.7
MIPI_DPHY_CSI2_RX_CLKN: CN2.76 J16.10
MIPI_DPHY_CSI2_RX_CLKP: CN2.78 J16.9
MIPI_DPHY_CSI2_RX_D0N: CN2.68 J16.12
MIPI_DPHY_CSI2_RX_D0P: CN2.70 J16.11
MIPI_DPHY_CSI2_RX_D1N: CN2.72 J16.8
MIPI_DPHY_CSI2_RX_D1P: CN2.74 J16.7
MIPI_DPHY_CSI3_RX_CLKN: CN4.65 J18.10
MIPI_DPHY_CSI3_RX_CLKP: CN4.67 J18.9
MIPI_DPHY_CSI3_RX_D0N: CN4.61 J18.12
MIPI_DPHY_CSI3_RX_D0P: CN4.63 J18.11
MIPI_DPHY_CSI3_RX_D1N: CN4.57 J18.8
MIPI_DPHY_CSI3_RX_D1P: CN4.59 J18.7
MIPI_DPHY_CSI4_RX_CLKN: CN4.51 J17.10
MIPI_DPHY_CSI4_RX_CLKP: CN4.53 J17.9
MIPI_DPHY_CSI4_RX_D0N: CN4.47 J17.12
MIPI_DPHY_CSI4_RX_D0P: CN4.49 J17.11
MIPI_DPHY_CSI4_RX_D1N: CN4.43 J17.8
MIPI_DPHY_CSI4_RX_D1P: CN4.45 J17.7
MIPI_DPHY_DSI_TX_CLKN: CN3.12 J13.24
MIPI_DPHY_DSI_TX_CLKP: CN3.14 J13.23
MIPI_DPHY_DSI_TX_D0N: CN3.20 J13.27
MIPI_DPHY_DSI_TX_D0P: CN3.22 J13.26
MIPI_DPHY_DSI_TX_D1N: CN3.16 J13.21
MIPI_DPHY_DSI_TX_D1P: CN3.18 J13.20
MIPI_DPHY_DSI_TX_D2N: CN3.8 J13.18
MIPI_DPHY_DSI_TX_D2P: CN3.10 J13.17
MIPI_DPHY_DSI_TX_D3N: CN3.4 J13.30
MIPI_DPHY_DSI_TX_D3P: CN3.6 J13.29
ON/OFF: C30.1 D13.2 R31.1 SW3.2
PCIE0_CLKREQN_M0: CN2.26 R181.1
PCIE0_PERSTN: CN2.28 R183.2
PCIE0_REFCLKN: CN4.44 J20.11
PCIE0_REFCLKP: CN4.46 J20.13
PCIE0_RXN: CN4.34 J20.23
PCIE0_RXP: CN4.36 J20.25
PCIE0_TXN: C170.1 CN4.38
PCIE0_TXP: C171.1 CN4.40
PCIE0_WAKEN_M0: CN2.24 R180.1
PE_TXN: C170.2 J20.31
PE_TXP: C171.2 J20.33
PMIC_EXT_EN: CN4.30 R199.1
PWM0_CH0_M0_IR: CN2.33 R21.2 R26.1
PWM2_CH3_M3: CN3.68 J32.11
PWM2_CH6_M3: CN3.66 J32.10
PWM2_CH7_M3: CN3.64 J32.8
PWR_3V3_EN: CN2.27 R195.1
PWR_5V_EN: CN2.25 R200.1
PWR_12V_EN: CN2.29 R193.1
PWR_ON: CN4.28 Q12.3 R31.2
RECOVERY: C27.1 D12.2 R30.1 SW2.2
RECOVERY_KEY: CN4.27 R30.2
RK806_VDC: CN2.37 R198.1
RMII0_AVDD33: C46.1 C47.1 C48.1 L5.2 R52.2 U7.11 U7.40
RMII0_LED1: J6.14 R56.1 U7.33
RMII0_LED2: J6.11 R54.1 U7.34
RMII0_MDIN0: J6.3 U7.2
RMII0_MDIN1: J6.7 U7.5
RMII0_MDIN2: J6.6 U7.7
RMII0_MDIN3: J6.9 U7.10
RMII0_MDIP0: J6.2 U7.1
RMII0_MDIP1: J6.4 U7.4
RMII0_MDIP2: J6.5 U7.6
RMII0_MDIP3: J6.8 U7.9
RMII0_VDD10: C36.1 C37.1 C38.1 C39.1 C40.1 L4.2 U7.3 U7.8 U7.21 U7.38
RMII1_AVDD33: C62.1 C63.1 C64.1 L7.2 R76.2 U8.11 U8.40
RMII1_LED1: J7.14 R80.1 U8.33
RMII1_LED2: J7.11 R79.1 U8.34
RMII1_MDIN0: J7.3 U8.2
RMII1_MDIN1: J7.7 U8.5
RMII1_MDIN2: J7.6 U8.7
RMII1_MDIN3: J7.9 U8.10
RMII1_MDIP0: J7.2 U8.1
RMII1_MDIP1: J7.4 U8.4
RMII1_MDIP2: J7.5 U8.6
RMII1_MDIP3: J7.8 U8.9
RMII1_VDD10: C52.1 C53.1 C54.1 C55.1 C56.1 L6.2 U8.3 U8.8 U8.21 U8.38
ROUT1: C82.2 U9.11
ROUT2: C211.1 U9.14
RS232_R1IN: J24.4 U33.13
RS232_R1OUT: J27.1 U33.12
RS232_R2IN: J24.1 U33.8
RS232_R2OUT: J28.1 U33.9
RS232_T1IN: J27.2 U33.11
RS232_T1OUT: J24.6 U33.14
RS232_T2IN: J28.2 U33.10
RS232_T2OUT: J24.3 U33.7
RS485_1_3V3: C198.1 D41.2 L16.2 U36.8(VCC)
RS485_1_A: DN1.2(C2) J31.2 R211.2 R213.1 U36.6
RS485_1_B: DN1.1 J31.1 R211.1 R214.1 U36.7
RS485_1_DIR: CN2.4 R212.1 U36.2 U36.3
RS485_2_3V3: C199.1 D42.2 L17.2 U37.8(VCC)
RS485_2_A: DN2.2(C2) J31.4 R215.1 R216.2 U37.6
RS485_2_B: DN2.1 J31.3 R216.1 R218.1 U37.7
RS485_2_DIR: CN2.6 R217.1 U37.2 U37.3
RTC_32K_IN: CN2.55 R29.2
RTC_INT: CN2.43 D18.2 R156.2
SAI1_LRCK_M0: CN5.61 U9.7
SAI1_MCLK_M0: CN5.57 U9.1
SAI1_SCLK_M0: CN5.59 U9.5
SAI1_SDI0_M0: CN5.53 U9.8
SAI1_SDO2_M0: CN5.55 U9.6
SARADC_IN3: CN2.44 R15.2 R16.1 R207.1
SARADC_IN5: CN2.46 R208.1
SARADC_IN6: CN2.48 R209.1
SARADC_IN7: CN2.50 R210.1
SDMMC0_CLK: CN5.35 R20.1
SDMMC0_CMD: CN5.39 R19.1
SDMMC0_D0: CN5.47 R23.1
SDMMC0_D1: CN5.45 R24.1
SDMMC0_D2: CN5.43 R17.1
SDMMC0_D3: CN5.41 R18.1
SDMMC0_DETN: CN5.49 R25.1
SIM_CLK0: J20.12 R174.1
SIM_DATA0: J20.10 R175.1
SIM_RST0: J20.14 R173.1
SIM_VDD: J19.1 J20.8 R171.1 U27.1
SPI1_CLK_M0: CN4.71 J32.12
SPI1_CSN1_M0: CN4.77 J32.16
SPI1_MISO_M0: CN4.75 J32.15
SPI1_MOSI_M0: CN4.73 J32.13
SPK_CTRL: CN3.72 R102.1 R225.1
SPK_LN: C205.1 J9.1 L18.2
SPK_LP: C90.1 J9.2 L19.2
SPK_RN: C214.1 J22.1 L20.2
SPK_RP: C213.1 J22.2 L21.2
SUB1: C105.1 D23.2 J10.A8 R119.1 R123.1
SUB2: C106.1 D24.2 J10.B8 R122.1 R124.1
SYS_LED: CN3.70 LED2.1(CATHODE)
TYPEC_CC1: C96.1 D21.2 J10.A5 U11.10 U11.11
TYPEC_CC2: C95.1 D22.2 J10.B5 U11.1 U11.14
TYPEC_DM: D20.2 J10.A7 J10.B7 R108.1
TYPEC_DP: D19.2 J10.A6 J10.B6 R107.1
TYPEC_DPTX_AUX_PUPDCTL1: CN3.28 R119.2
TYPEC_DPTX_AUX_PUPDCTL2: CN3.26 R122.2
TYPEC_SSRXN1: J10.B10 R113.1 U16.5 U16.6(NC4)
TYPEC_SSRXN2: J10.A10 R117.1 U14.5 U14.6(NC4)
TYPEC_SSRXP1: J10.B11 R112.1 U16.4 U16.7
TYPEC_SSRXP2: J10.A11 R114.1 U14.4 U14.7
TYPEC_SSTXN1: C100.1 J10.A3 U16.1 U16.10
TYPEC_SSTXN2: C102.1 J10.B3 U14.1 U14.10
TYPEC_SSTXP1: C99.1 J10.A2 U16.2 U16.9
TYPEC_SSTXP2: C101.1 J10.B2 U14.2 U14.9
TYPEC_VBUS_EN: CN2.41 R118.1
U8_RX: J25.3 J27.5
U8_TX: J25.2 J27.6
U10_RX: J26.3 J28.5
U10_TX: J26.2 J28.6
UART0_RX: R187.2 U29.2
UART0_RX_M0_DEBUG: CN4.66 U29.4
UART0_TX: R186.2 U28.4
UART0_TX_M0_DEBUG: CN4.64 U28.2
UART3_RX_M1: CN5.64 U36.1
UART3_TX_M1: CN5.66 U36.4
UART5_RX_M0: CN5.70 U37.1
UART5_TX_M0: CN5.68 U37.4
UART8_RX: D38.2 J27.3 R203.2
UART8_RX_M2: CN5.52 R203.1
UART8_TX: D37.2 J27.4 R204.2
UART8_TX_M2: CN5.54 R204.1
UART10_RX: D40.2 J28.3 R201.2
UART10_RX_M1: CN4.58 R201.1
UART10_TX: D39.2 J28.4 R202.2
UART10_TX_M1: CN4.56 R202.1
USB2_OTG0_DM: CN3.40 R108.2
USB2_OTG0_DP: CN3.42 R107.2
USB2_OTG0_ID: CN3.30 R104.2
USB2_OTG0_VBUSDET: CN3.32 R103.2
USB2_OTG1_DM: CN3.36 R132.1
USB2_OTG1_DP: CN3.38 R131.1
USB2_OTG1_ID: CN3.27 R137.2
USB2_OTG1_VBUSDET: CN3.25 R136.2
USB3_OTG0_SSRX1N: CN3.43 R113.2
USB3_OTG0_SSRX1P: CN3.45 R112.2
USB3_OTG0_SSRX2N: CN3.35 R117.2
USB3_OTG0_SSRX2P: CN3.37 R114.2
USB3_OTG0_SSTX1N: C100.2 CN3.39
USB3_OTG0_SSTX1P: C99.2 CN3.41
USB3_OTG0_SSTX2N: C102.2 CN3.31
USB3_OTG0_SSTX2P: C101.2 CN3.33
USB3_OTG1_SSRXN: CN4.37 R110.2
USB3_OTG1_SSRXP: CN4.39 R111.2
USB3_OTG1_SSTXN: C97.2 CN4.33
USB3_OTG1_SSTXP: C98.2 CN4.35
USB20_DM2: J11.11 R115.1 U15.2 U15.9
USB20_DP2: J11.12 R116.1 U15.1 U15.10
USB20_HOST_PWR_EN: CN2.47 R134.1
USB30_DM: J11.2 R105.1 U17.5 U17.6(NC4)
USB30_DP: J11.3 R106.1 U17.4 U17.7
USB30_HOST_PWR_EN: CN2.49 R121.1
USB30_RXN: J11.5 R110.1 U17.1 U17.10
USB30_RXP: J11.6 R111.1 U17.2 U17.9
USB30_TXN: C97.1 J11.8 U15.4 U15.7
USB30_TXP: C98.1 J11.9 U15.5 U15.6(NC4)
USB_HUB_1V8: C123.1 C124.1 C125.1 C126.1 C127.1 U19.6 U19.21 U19.25 U19.28
USB_HUB_3V3: C109.1 C110.1 C116.1 C117.1 C118.1 C120.1 C121.1 R127.2 R128.2 R129.2 R130.2 U19.15 U19.20 U19.26 U19.31 U19.36 U19.42 U19.43 U19.45
USB_HUB_3V3_OUT: C114.1 C115.1 R128.1 U19.9
USB_HUB_5V0: C112.1 C113.1 R126.2 U19.8
USB_HUB_DM1: R105.2 U19.18
USB_HUB_DM2: R115.2 U19.16
USB_HUB_DM3: J12.2 U18.2 U18.9 U19.13
USB_HUB_DM4: J12.8 U18.5 U18.6(NC4) U19.11
USB_HUB_DM5: D33.1 R184.2 U19.32
USB_HUB_DM6: R143.1 U19.34
USB_HUB_DP1: R106.2 U19.19
USB_HUB_DP2: R116.2 U19.17
USB_HUB_DP3: J12.3 U18.1 U18.10 U19.14
USB_HUB_DP4: J12.9 U18.4 U18.7 U19.12
USB_HUB_DP5: D32.1 R185.2 U19.33
USB_HUB_DP6: R138.1 U19.35
WIFI_PWR_EN: CN4.79 R155.1
N16958730: J1.1 J1.5 L2.1
N16958788: F1.1 J1.4
N16959452: R3.2 U1.5
N16959455: C1.2 L1.1 U1.2
N16959584: C2.1 R1.1 R2.1 U1.4
N16961177: C10.2 L3.1 U2.2
N16961195: C11.1 R6.1 R7.1 U2.4
N16961300: R8.1 R9.1 U2.5
N16963036: LED1.2 R4.2
N16963423: LED2.2 R12.2
N16965184: D8.2 J4.1 R17.2
N16965201: D7.2 J4.2 R18.2
N16965205: D6.2 J4.3 R19.2
N16965209: D5.2 J4.5 R20.2
N16965213: D4.2 J4.7 R23.2
N16965217: D3.2 J4.8 R24.2
N16965221: D2.2 J4.9 R25.2
N16966392: R26.2 U4.3
N16966399: C22.1 C23.1 R22.2 U4.2(VCC)
N16970771: R39.2 U7.23
N16970773: R36.2 U7.24
N16970775: R37.2 U7.25
N16970777: R42.2 U7.26
N16970779: R41.2 U7.27
N16970781: R40.2 U7.22
N16970797: R49.2 U7.35
N16970858: C42.1 U7.36 Y2.3
N16970862: C41.1 U7.37(XTAL_OUT) Y2.1
N16970890: C45.1 D59.2 R53.2 R158.2 U7.12
N16971097: R38.1 U7.39
N16971189: L4.1 U7.30
N16971238: C43.1 J6.1
N16971261: C44.1 J6.15 J6.16 R55.1
N16971318: J6.12 R50.1
N16971320: J6.13(YELC) R51.1
N16971466: R52.1 U7.32
N16971541: R46.2 U7.31
N16976499: R68.2 U8.26
N16976501: R60.2 U8.25
N16976503: R61.2 U8.24
N16976505: R63.2 U8.23
N16976507: R64.2 U8.22
N16976509: R67.2 U8.27
N16976515: R73.2 U8.35
N16976541: C57.1 U8.37(XTAL_OUT) Y3.1
N16976545: C58.1 U8.36 Y3.3
N16976569: C61.1 D60.2 R77.2 R159.2 U8.12
N16976627: R62.1 U8.39
N16976649: L6.1 U8.30
N16976697: R76.1 U8.32
N16976807: C59.1 J7.1
N16976813: C60.1 J7.15 J7.16 R78.1
N16976831: J7.13(YELC) R75.1
N16976833: J7.12 R74.1
N16976861: R70.2 U8.31
N16985416: J10.1 J10.2 J10.3 J10.4 L11.1
N16990092: R120.1 U12.3
N16998300: Q10.2(SOURCE) R150.2 R152.2
N17003573: Q18.1 Q19.1 Q20.1 Q21.1 R164.2 R165.1
N17013167: Q8.1 Q9.3 R142.2
N17014356: Q9.1 R149.1 R151.1
N17018699: J15.1 J15.2 J15.3 R167.2
N17022868: J16.1 J16.2 J16.3 R168.2
N17023671: J18.1 J18.2 J18.3 R170.2
N17024139: J17.1 J17.2 J17.3 R169.2
N17026345: J14.1 J14.2 J14.3 R166.2
N17029455: C148.1 R153.2 U24.4 U25.4
N17029502: R154.1 U24.3
N17029521: R161.1 U25.3
N17036087: C169.1 J19.2 R173.2 U27.6
N17036090: C168.1 J19.3 R174.2 U27.4
N17036093: C167.1 J19.7 R171.2 R175.2 U27.5
N17043489: C161.2 L14.1 U26.2
N17043505: C161.1 U26.6
N17043533: C164.1 R172.1 R176.1 U26.4
N17043616: R177.2 R178.1 U26.5
N17043933: J20.1 R179.2 R180.2
N17044212: J20.7 R181.2
N17046085: J20.38 R185.1
N17046088: J20.36 R184.1
N17046548: J20.20 R182.1
N17046561: J20.22 R183.1
N17063858: C66.1 C67.1 C68.1 C69.1 L8.2 U9.16 U9.17
N17063899: C72.1 C73.1 L9.2 U9.2 U9.3
N17064255: C71.1 U9.24
N17064258: C74.1 U9.23
N17064495: C75.1 U9.22
N17064497: C76.1 U9.21
N17064707: C78.1 U9.20
N17064710: C79.1 U9.19
N17064713: C80.1 U9.10(VREF)
N17064960: R91.2 U9.26
N17065329: C85.1 R97.1 R99.1
N17072089: C65.1 D14.2 J8.1 R81.1 R83.1 R84.2
N17072509: C70.1 R82.1 R84.1
N17073944: J8.2 R92.1
N17074279: C83.1 D15.2 J8.6 R87.2 R88.1
N17074336: D17.2 J8.3 Q5.2(SOURCE) R243.1
N17074726: D16.2 J8.4 Q4.2(SOURCE) R242.1
N17074747: Q4.3 R89.1 R90.1
N17075125: C81.1 R89.2
N17075408: Q5.3 R93.1 R94.1
N17075443: C82.1 R93.2
N17075521: C84.1 Q4.1 Q5.1 R95.1
N17112236: C29.1 U5.2 Y1.2
N17112246: C28.1 U5.1 Y1.1
N17112592: R28.2 R29.1 U5.7
N17115633: Q3.3 Q12.1 R241.2
N17117541: R118.2 U12.4
N17135429: R5.1 U3.3
N17149641: R121.2 U13.4
N17149662: R125.1 U13.3
N17150434: J11.19 J11.20 J11.21 J11.22 L10.1
N17156781: R133.1 U19.27
N17157129: C131.1 U19.22 Y4.3
N17157136: C130.1 U19.23 Y4.1
N17158781: C122.1 R130.1 U19.41
N17159812: R129.1 U19.40
N17161099: R131.2 U19.30
N17161102: R132.2 U19.29
N17163205: J12.5 J12.6 J12.11 J12.12 L12.1
N17166688: C132.1 R134.2 U20.4
N17166697: R135.1 U20.3
N17204481: D34.2 J21.2 R187.1
N17204515: D35.2 J21.1 R186.1
N17208013: Q1.3 R11.1
N17208331: D1.1(K) J2.1 R11.2
N17208813: Q1.1 Q2.3 R10.2
N17208925: Q2.1 R13.2 R14.1
N17240897: C180.2 Q15.1 Q16.1 Q17.3 R192.2
N17241015: Q15.2(SOURCE) R191.1
N17241092: Q16.2(SOURCE) R191.2
N17241660: Q17.1 R193.2 R194.1
N17241919: C184.1 R195.2 U31.4
N17241951: R196.1 U31.3
N17242291: C188.1 R200.2 U32.4
N17242323: R197.1 U32.3
N17257942: R199.2 U3.4
N17272255: C191.1 L15.1 U33.16(VCC)
N17272410: C192.1 U33.3
N17272413: C192.2 U33.1
N17272453: C193.2 U33.4
N17272456: C193.1 U33.5
N17272490: C194.1 U33.6
N17272493: C195.1 U33.2
N17276502: D29.2 J30.2 R207.2
N17276503: D28.2 J30.3 R208.2
N17276504: D27.2 J30.4 R209.2
N17276505: D26.2 J30.5 R210.2
N17284003: D41.1 R213.2
N17284390: D42.1 R215.2
N17313600: C200.1 C201.1 C202.1 C203.1 C204.1 R219.2 R220.2 U38.6
N17313897: R96.2 U38.4
N17313900: R98.2 U38.3
N17314015: C87.2 R98.1
N17314022: C86.2 R96.1
N17314158: R100.1 R102.2 U38.1
N17314600: C88.1 U38.2
N17314610: L18.1 U38.5
N17314613: L19.1 U38.8(VOP)
N17315365: C206.1 C207.1 C208.1 C209.1 C210.1 R221.2 R222.2 U10.6
N17315397: R224.2 U10.3
N17315399: R223.2 U10.4
N17315425: C212.2 R224.1
N17315432: C211.2 R223.1
N17315446: R225.2 R226.1 U10.1
N17315502: C215.1 U10.2
N17315506: L21.1 U10.8(VOP)
N17315508: L20.1 U10.5
N17318769: J33.G1 J33.G2 J33.G3 J33.G4 L27.2
N17319613: Q21.3 R233.2 R234.2
N17319615: Q20.3 R231.2 R232.2
N17319817: Q19.3 R229.2 R230.2
N17319825: Q18.3 R227.2 R228.2
N17366542: C136.1 C140.1 U22.2
N17366552: C137.1 C140.2 CN1.1
N17367118: R138.2 U22.6
N17367190: R143.2 U22.7
N17367932: C143.2 Q11.1 R148.2 R155.2
N17617847: C1.1 U1.6
N17618789: C10.1 U2.6

Pads without a net: CN3 53 55 57 59 63 65 67 69 73 75; CN4 50 52 70 72 74 76 78 80; J8 7 8; J11 14 15 17 18; J13 14; J14 13 14; J15 13 14 16 17 19 20; J16 13 14 16 17 19 20; J17 13 14 16 17 19 20; J18 13 14 16 17 19 20; J19 4 6; J20 3 5 6 16 17 19 28 30 32 42 44 45 46 47 48 49 51; J25 1; J26 1; J32 7; U9 9 25; U19 1 2 3 4 5 7 37 38 44 46 47 48; U22 3 4 9 10 11 12 13 14; U27 3

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 2258 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3_WLAN: length 5.3
  TOP w0.508: U22.8 121.58,43.15 C142.1 C141.1 120.34,43.19 119.96,43.56 Q11.3
12V: length 9.4
  BOTTOM w0.254: v1(13.79,69.78) 12.8,68.79 12.8,64.16 12.4,63.75 R8.2
  BOTTOM w0.381: R219.1 v1(22.3,57.49) ; R221.1 32.83,57.49 v1(33.48,56.85)
  vias: v1(13.79,70.78) v1(14.79,70.78) v1(14.79,69.78) v1(15.79,70.78) v1(15.79,69.78) v1(22.3,58.49) v1(33.48,57.85) v1(88.03,7.7) v1(89.03,7.7) v1(90.03,7.7) v1(105.37,21.68) v1(105.37,20.68) v1(106.37,21.68) v1(106.37,20.68) v1(107.37,21.68) v1(107.37,20.68)
GND: length 1387.1
  TOP w0.152: CN2.66 v1(65.12,49.81) ; CN2.8 53.52,49.49 arc(53.46,49.78) 53.3,50.03 53.05,50.28 arc(52.95,50.42) 52.92,50.58 v1(52.92,50.79) ; CN4.9 53.92,15.51 arc(53.89,15.69) 53.78,15.85 53.72,15.91 arc(53.64,16.02) 53.62,16.15 53.62,17.73 arc(53.7,17.93) 53.9,18.01 55.16,18.01 arc(55.33,17.98) 55.47,17.88 55.63,17.73 ; 55.63,17.73 55.91,18.01 arc(56.26,18.16) 56.62,18.01 v1(57.12,17.51) 56.86,17.25 arc(56.7,17) 56.64,16.71 56.64,16.5 arc(56.67,16.32) 56.77,16.17 56.9,16.05 arc(57.06,15.8) 57.12,15.51 CN4.25 ; 55.63,17.73 55.63,15.9 55.63,15.86 55.79,15.7 arc(55.89,15.55) 55.92,15.37 CN4.19 ; 61.52,26.37 59.36,26.37 ; C52.2 86.06,54.5 arc(85.82,54.34) 85.52,54.28 82.95,54.28 arc(82.86,54.26) 82.79,54.21 v1(82.7,54.13) ; CN2.13 54.72,44.93 arc(54.66,44.64) 54.5,44.39 54.15,44.04 arc(53.98,43.79) 53.92,43.5 v1(53.92,43.11) ; v1(57.96,12.88) 58.17,12.88 58.32,12.73 CN4.32 ; 60.25,18.21 60.63,17.83 60.63,16.53 arc(60.58,16.28) 60.44,16.06 60.22,15.85 ; CN3.29 81.52,46.72 81.71,46.91 ; 34.7,62.84 34.7,60.53
  TOP w0.203: 68.22,49.89 67.92,49.58 CN2.80 67.92,47.78 ; CN2.35 v1(59.12,47.15) ; CN3.44 v1(84.32,49.83) ; v1(90.52,47.15) 90.67,47.15 arc(90.76,47.13) 90.85,47.07 90.96,46.96 arc(91.08,46.78) 91.12,46.57 CN3.77 91.12,45.11 ; 81.33,43.36 81.52,43.55 CN3.29 ; v1(45.13,63.03) 45.29,62.87 U9.4 ; v1(77.14,47.22) 76.15,47.22 75.92,46.99 CN3.1 ; v1(80.37,47.27) 80.37,47.19 80.32,47.15 CN3.23 80.32,44.84 ; v1(87.92,45.11) CN3.61 v1(87.92,47.15) ; v1(62.92,44.11) 62.92,44.36 arc(62.96,44.54) 63.07,44.7 63.24,44.87 arc(63.45,45.19) 63.52,45.56 CN2.57 ; CN2.31 58.32,46.82 arc(58.3,46.94) 58.24,47.03 v1(58.12,47.15) ; 75.92,47.91 CN3.2 75.92,49.37 arc(75.89,49.52) 75.81,49.64 75.67,49.78 ; v1(89.52,47.15) 89.57,47.15 arc(89.82,47.04) 89.92,46.79 CN3.71 89.92,45.11 ; 86.16,45.11 86.03,45.24 arc(85.95,45.36) 85.92,45.49 CN3.51 85.92,46.79 arc(86.03,47.04) 86.27,47.15 v1(86.32,47.15) ; v1(80.29,49.73) 80.32,49.7 CN3.24 ; CN2.1 v1(52.32,47.15) ; 82.32,47.85 CN3.34 v1(82.32,49.81) ; CN2.23 v1(56.72,47.15) ; v1(61.92,50.79) 61.92,50.55 62.32,50.15 CN2.52 62.32,47.76 ; CN2.66 65.12,47.78 ; CN2.13 v1(54.72,47.15) ; v1(49.85,59.69) 49.66,59.69 49.03,60.31 U9.13 ; CN2.79 67.92,47.11 ; CN3.79 v1(91.52,47.15)
  TOP w0.254: v1(118.36,73.03) U15.8 U15.3 ; C121.2 v1(122.17,53.9) ; CN5.84 92,15.1 arc(92.03,15.24) 92.11,15.36 92.14,15.4 arc(92.26,15.48) 92.41,15.51 v1(92.72,15.51) ; CN4.20 55.92,11.2 55.9,11.18 ; C173.2 v1(136.59,22.47) ; v1(142.39,20.05) J13.16 144.55,20.05 ; v1(8.34,29.72) 8.35,29.72 C153.2 ; v1(134.37,70.54) U18.3 U18.8 v1(134.37,72.97) ; C58.2 v1(85.42,61.59) v1(86.42,61.59) ; CN4.54 62.72,12.72 v1(62.56,12.88) ; C131.2 116.12,57.78 v1(116.01,57.9) v1(116.01,56.9) v1(116.01,55.9) v1(116.01,54.9) v1(116.01,53.9) v1(116.9,53.9) v1(118.9,53.9) 119.51,53.9 ; Q2.2 v1(53,56.05) ; C205.2 v1(27.18,73.74) ; v1(93.52,49.79) v1(93.52,50.79) v1(93.52,51.79) ; v1(7.75,20.85) J14.18 5.64,20.85 ; D47.2 v1(18.52,11.81) D30.2 ; v1(105.22,67.05) 105.1,66.93 arc(105.03,66.83) 105.01,66.72 D56.1 ; U10.7 30.23,66.52 v1(30.3,66.6) ; J20.34 v1(128.99,20.54) ; 144.59,24.55 J13.25 v1(142.39,24.55) ; R65.2 v1(77.22,54.13) ; C174.2 131.7,7.04 arc(131.75,6.8) 131.88,6.6 v1(132.11,6.38) ; v1(132.51,9.5) 132.59,9.58 J20.43 v1(132.59,12.93) ; D34.1 v1(2.66,67.51) ; U29.3 v1(3.43,66.79) ; R44.2 v1(62.87,54.13) ; CN4.69 v1(65.92,13.96) ; C151.2 8.68,13.84 v1(8.67,13.85) v1(7.67,13.85) J14.4 ; 119.51,53.9 v1(119.9,53.9) 120.05,53.9 arc(120.33,54.02) 120.44,54.3 120.44,54.86 ; 119.51,53.9 119.51,53.91 Y4.4 120.43,54.88 120.44,54.86 ; C112.2 v1(126.86,70.71) ; v1(49.25,71.09) 49.1,71.25 arc(48.97,71.34) 48.81,71.37 R85.1 ; R43.2 v1(58.8,54.13) ; v1(130.39,12.93) 130.27,12.81 arc(130.21,12.72) 130.19,12.61 J20.37 ; v1(113.61,20.68) 113.79,20.5 J20.4 113.79,17.99 arc(113.77,17.89) 113.71,17.8 v1(113.59,17.68) ; v1(29.06,80.75) 29.15,80.75 arc(29.33,80.67) 29.41,80.49 D19.1 29.41,79.27 v1(29.24,79.1) ; 5.37,51.87 v1(5.51,51.87) J18.4 v1(7.75,51.87) ; v1(126.43,12.93) 126.29,12.79 arc(126.22,12.68) 126.19,12.54 J20.27 ; C142.2 121.54,44.88 ; J11.16 115.96,75.86 arc(115.94,75.98) 115.87,76.08 115.6,76.35 ; C214.2 33.02,73.18 arc(33.17,73.54) 33.53,73.69 v1(34.47,73.69) ; C42.2 v1(67.01,61.62) v1(68.86,61.62) v1(70.01,61.62) v1(71.01,61.62) v1(71.01,62.62) v1(71.01,63.62) v1(71.01,64.62) 71.01,66.15 arc(70.87,66.48) 70.53,66.62 v1(70.01,66.62) v1(69.01,66.62) v1(68.01,66.62) v1(67.01,66.62) C41.2 ; U4.1 v1(136.94,4.14) ; C78.2 v1(53.69,65.91) ; v1(82.7,54.13) 82.55,54.28 arc(82.46,54.41) 82.43,54.57 C54.2 ; v1(118.87,12.37) 118.44,12.37 118.19,12.12 J20.15 ; v1(117.73,65.53) 117.86,65.4 C116.2 ; 86.7,61.76 Y3.2 85.96,62.73 ; 144.54,23.05 J13.22 v1(142.39,23.05) ; C110.2 131.31,64.25 v1(130.56,63.5) ; v1(7.67,12.85) v1(8.67,12.85) 8.69,12.83 C152.2 ; C68.2 v1(52.96,59.99) ; 29.34,22.97 v1(29.34,21.97) ; CN4.42 60.32,12.38 arc(60.36,12.56) 60.45,12.7 v1(60.62,12.87) ; U9.18 51.11,62.87 51.13,62.84 v1(51.14,62.84) ; C90.2 v1(22.86,73.74) ; C88.2 v1(24.38,56.59) ; CN5.15 78.72,18.18 arc(78.74,18.29) 78.8,18.38 78.92,18.49 v1(78.92,18.52) ; 58.32,14.15 CN4.31 58.32,16.01 arc(58.3,16.12) 58.24,16.21 58.12,16.32 v1(58.12,16.51) ; v1(100.82,66.8) D52.1 ; Q20.2 106.63,56.05 arc(106.43,56.01) 106.26,55.89 v1(106.07,55.7) ; U4.4 v1(140.75,4.14) ; C213.2 28.7,73.74 ; C215.2 v1(30.23,56.59) ; D57.2 v1(25.07,11.81) ; 116.22,56.38 Y4.2 117.21,57.21 ; C52.2 v1(87.12,54.86) ; v1(74.07,49.79) v1(74.07,50.79) v1(74.07,51.79) ; C120.2 116.99,62.23 v1(116.69,61.93) ; R14.2 v1(51.55,57.65) ; 70.62,65.03 Y2.4 69.79,66.05 ; 56.9,11.18 57.03,11.31 arc(57.1,11.41) 57.12,11.54 CN4.26 ; U29.1 v1(3.43,68.09) ; v1(60.32,15.51) CN4.41 60.32,14.17 ; 120.44,54.86 120.44,56.89 arc(120.5,57.15) 120.64,57.37 v1(120.88,57.61) v1(120.88,58.61) v1(119.88,58.61) C130.2 ; J10.B1 25.3,85.39 25.15,85.55 v1(25.1,85.55) ; v1(8.34,30.74) 8.35,30.73 C154.2 ; 144.66,26.05 J13.28 v1(142.39,26.05) ; 88.2,66 Y3.4 89.02,65.03 ; C109.2 v1(131.32,67.04) ; v1(99.62,56.13) 99.71,56.05 Q8.2 ; D50.1 v1(96.54,66.55) ; J13.6 v1(142.39,15.05) ; C66.2 C67.2 v1(53.7,63.87) ; v1(91.84,67.96) 92.74,67.96 ; L11.2 34.42,84.68 v1(34.56,84.54) ; J20.35 v1(129.39,12.93) ; 99.59,81.66 J33.2 100.33,80.9 ; C141.2 v1(120.52,44.88) ; U22.5 121.39,34.32 ; J20.21 123.79,9.78 arc(123.75,9.58) 123.63,9.41 v1(123.44,9.22) ; C22.2 v1(137.54,9.25) ; C117.2 v1(132.07,58.03) ; v1(92.71,66.65) 92.6,66.54 D54.1 ; L2.2 v1(21.34,85.04) ; v1(68.5,15.52) 68.4,15.41 CN4.84 ; CN4.68 65.52,12.77 v1(65.62,12.87) ; v1(88.33,66.29) v1(87.33,66.29) 87.32,66.29 v1(85.42,66.29) C57.2 ; CN3.24 80.32,47.31 v1(80.37,47.27) ; CN4.48 61.52,12.77 v1(61.62,12.87) ; C122.2 v1(132.07,62.22) ; R45.2 v1(61.85,54.13) ; C203.2 v1(25.02,73.74) ; C189.2 v1(19.12,17.08) ; D25.2 v1(11.96,11.81) ; R165.2 v1(91.06,54.86) ; C87.1 v1(24.83,54.87) ; 68.29,61.79 Y2.2 67.55,62.73 ; v1(21.33,21.97) 21.47,22.12 arc(21.55,22.24) 21.58,22.38 C194.2 ; J13.7 v1(144.59,15.55) ; CN5.1 75.92,16.26 arc(75.83,16.75) 75.55,17.16 74.89,17.82 arc(74.77,18.01) 74.72,18.22 v1(74.72,18.51) v1(74.72,19.51) v1(74.72,20.51) ; C124.2 v1(127.89,70.71) ; 123.47,66.14 U19.10 123.47,68.27 v1(123.44,68.3) 123.76,68.61 arc(123.81,68.7) 123.83,68.8 C114.2 ; U17.3 U17.8 v1(113.54,73.03) ; 16.28,42.36 15.4,42.36 v1(15.29,42.47) ; D55.1 v1(107.31,65.79) ; 63.12,15.59 v1(63.12,15.57) CN4.55 63.12,14.13 ; R66.2 v1(76.2,54.13) ; C196.2 v1(12.7,18.69) ; J33.8 100.32,77.43 ; C23.2 v1(138.56,9.25) ; J13.8 v1(142.39,16.05) ; 25.05,83.71 J10.A12 25.05,82.46 24.82,82.22 ; 144.54,21.55 J13.19 v1(142.39,21.55) ; C212.1 v1(30.71,54.87) ; J18.18 v1(5.5,58.87) ; v1(24.46,66.6) 24.38,66.52 U38.7 ; D20.1 25.96,80.53 v1(25.96,81.23) ; R151.2 v1(97.66,54.86) ; v1(137.62,0.79) 137.62,0.79 LED1.1 ; 30.78,82.4 30.55,82.63 J10.A1 ; v1(13.79,68.78) 13.97,68.61 C15.2 ; C115.2 v1(123.83,70.71) ; U28.3 v1(7.31,79.78) ; U19.39 v1(128.27,61.11) ; C123.2 121.16,54.31 arc(121.13,54.16) 121.05,54.04 v1(120.9,53.9) ; C209.2 30.86,73.74 ; J15.4 7.55,33.05 v1(7.59,33.1) ; DN2.3 v1(26.12,12.7) ; Q21.2 v1(93.12,56.05) ; C73.2 v1(42.62,63.37) ; DN1.3 v1(31.55,11.81) ; J18.24 v1(5.5,61.87) ; C125.2 v1(123.19,53.9) ; C50.2 v1(84.15,57.28) ; Q18.2 v1(102.9,56.05) ; C69.2 v1(51.94,59.99) ; U19.24 v1(119.95,60.11) ; R69.2 v1(80.26,54.13) ; D1.2 v1(42.59,54.56) ; Q19.2 v1(89.81,56.05) ; C172.2 v1(125.09,23.16) ; v1(73.24,7.97) 73.24,8.4 ; R100.2 v1(23.11,56.59) ; v1(82.47,17.55) 82.47,17.12 82.55,17.04 82.55,16.16 arc(82.53,16.04) 82.45,15.93 82.42,15.9 arc(82.35,15.79) 82.32,15.66 CN5.33 ; Q9.2 v1(96.42,56.05) ; J10.B12 30.81,83.75 ; C70.2 v1(44.74,70.37) ; C198.2 v1(39.37,10.63) ; C51.2 v1(84.15,58.29) ; C118.2 v1(128.27,54.15) ; D35.1 v1(2.66,79.08) ; C36.2 v1(68.76,54.86) ; C127.2 v1(117.14,60.21)
  TOP w0.381: v1(24.51,81.23) U14.8 U14.3 ; U34.2 v1(24.26,18.67) ; U33.15 v1(15.74,30.14) ; U34.8 v1(25.53,16.38) ; R217.2 v1(29.34,21.97) ; C195.2 v1(13.49,25.92) ; C191.2 v1(13.49,28.33) ; U16.3 U16.8 v1(31.37,81.23) ; C197.2 v1(17.53,21.97) ; R212.2 v1(35.56,21.97) ; U36.5 v1(35.43,13.72) ; U37.5 v1(28.7,13.72) ; U35.8 v1(18.16,16.38) ; U35.2 16.89,18.67 ; C190.2 v1(24.89,21.97)
  TOP w0.508: J11.4 113.19,80.38 ; J11.4 111.73,80.38 ; J11.4 112.46,81.11 ; 130.36,74.52 J12.4 ; J12.4 130.36,76.48 ; J12.4 131.33,75.5 ; J12.4 129.38,75.5 ; 43.92,44.14 SS10.1 ; SS10.1 47.2,47.41 ; SS10.1 43.92,50.69 ; SS10.1 40.64,47.41 ; J20.54 109.74,12.99 ; J20.54 109.74,10.04 ; J20.54 108.48,11.51 ; 143.57,73 SW2.1 ; SW2.1 144.45,72.12 ; SW2.1 144.45,73.88 ; SW2.1 145.33,73 ; SS7.1 136.49,65.89 ; SS7.1 139.32,63.06 ; SS7.1 133.66,63.06 ; SS7.1 136.49,60.23 ; 146.29,49.07 J32.14 ; J32.14 147.27,50.05 ; J32.14 147.27,48.09 ; J32.14 148.25,49.07 ; J1.3 18.46,81.2 ; J1.3 17.53,79.67 ; J1.3 18.46,78.15 ; J1.3 19.39,79.67 ; J24.2 60.66,6.05 ; J24.2 59.59,7.13 ; J24.2 59.59,4.97 ; J24.2 58.51,6.05 ; J32.6 148.25,59.23 ; J32.6 146.29,59.23 ; J32.6 147.27,58.25 ; J32.6 147.27,60.21 ; 143.75,54.15 J32.9 ; J32.9 144.73,53.17 ; J32.9 144.73,55.13 ; J32.9 145.71,54.15 ; 96.64,47.41 SS9.1 ; SS9.1 103.2,47.41 ; SS9.1 99.92,44.14 ; SS9.1 99.92,50.69 ; 110.34,3.71 J25.4 108.89,3.71 ; J14.25 3.86,26.53 ; J14.25 2.68,25.55 ; J14.25 5.04,25.55 ; J14.25 3.86,24.57 ; J23.6 69.5,3.71 ; J23.6 68.04,3.71 ; J23.6 68.77,4.44 ; SW2.3 146.4,75.43 ; SW2.3 146.4,73.67 ; SW2.3 147.28,74.55 ; SW2.3 145.52,74.55 ; 139.04,10.04 J20.53 ; J20.53 139.04,12.99 ; J20.53 137.78,11.51 ; J20.53 140.29,11.51 ; SS6.1 43.92,16.69 ; SS6.1 47.2,13.41 ; SS6.1 40.64,13.41 ; SS8.1 115.12,63.06 ; SS8.1 112.29,65.89 ; SS8.1 109.46,63.06 ; SS8.1 112.29,60.23 ; 145.52,80.03 SW1.3 ; SW1.3 146.4,79.15 ; SW1.3 146.4,80.91 ; SW1.3 147.28,80.03 ; J32.18 147.27,44.97 ; J32.18 147.27,43.01 ; J32.18 148.25,43.99 ; J32.18 146.29,43.99 ; J1.2 13.16,81.2 ; J1.2 13.16,78.15 ; J1.2 12.24,79.67 ; J1.2 14.09,79.67 ; SW3.1 145.33,67.51 ; SW3.1 144.45,68.39 ; SW3.1 143.57,67.51 ; SW3.1 144.45,66.64 ; J15.26 5.04,29.85 ; J15.26 3.86,28.87 ; J15.26 3.86,30.83 ; J18.25 5.04,63.57 ; J18.25 2.68,63.57 ; J18.25 3.86,62.59 ; 116.69,78.88 J11.7 115.96,78.15 ; 47.08,6.05 J24.5 ; J24.5 48.16,7.13 ; J24.5 48.16,4.97 ; J24.5 49.23,6.05 ; 99.92,10.14 SS5.1 ; SS5.1 96.64,13.41 ; SS5.1 103.2,13.41 ; 77.5,3.71 J23.2 76.04,3.71 ; J18.26 3.86,49.65 ; J18.26 3.86,47.69 ; J18.26 5.04,48.67 ; 84.45,3.71 J30.6 82.99,3.71 ; 146.19,11.37 J13.32 145.01,10.4 ; J15.25 3.86,45.73 ; J15.25 5.04,44.75 ; J15.25 3.86,43.77 ; 38.24,57.67 J5.2 37.61,57.04 ; 146.19,28.22 J13.31 ; J13.31 145.01,29.2 ; J13.31 147.37,29.2 ; J13.31 146.19,30.17 ; SW3.3 146.4,69.94 ; SW3.3 147.28,69.06 ; SW3.3 145.52,69.06 ; SW3.3 146.4,68.19 ; 73.5,3.71 J23.4 72.04,3.71 ; SW1.1 145.33,78.48 ; SW1.1 144.45,77.6 ; SW1.1 144.45,79.36 ; SW1.1 143.57,78.48 ; 1.31,70.73 J21.3 ; J21.3 2.29,69.76 ; J21.3 2.29,71.71 ; J12.10 131.33,78.5 ; J12.10 129.38,78.5 ; J12.10 130.36,77.52 ; J12.10 130.36,79.48 ; 99.4,3.71 J26.4 97.94,3.71 ; 3.86,11.63 J14.26 5.04,10.65 ; 38.11,62.92 J2.2 38.11,61.51
  GND02 w0.254: J33.5 97.87,79.15 ; J33.11 97.84,75.69 ; J33.8 100.42,77.43 ; 72.24,76.96 72.24,79.22 ; J33.17 97.75,72.22
  GND02 w0.508: 143.57,73 SW2.1 ; SW2.1 144.45,72.12 ; SW2.1 145.33,73 ; SW2.1 144.45,73.88 ; J32.18 148.25,43.99 ; J32.18 146.29,43.99 ; J32.18 147.27,43.01 ; J32.18 147.27,44.97 ; J32.9 145.71,54.15 ; J32.9 144.73,53.17 ; J32.9 143.75,54.15 ; J32.9 144.73,55.13 ; J2.2 38.82,62.21 ; J2.2 38.11,62.92 ; J2.2 37.41,62.21 ; J2.2 38.11,61.51 ; 13.16,78.15 J1.2 ; J1.2 12.24,79.67 ; J1.2 14.09,79.67 ; J1.2 13.16,81.2 ; 143.57,78.48 SW1.1 ; SW1.1 145.33,78.48 ; SW1.1 144.45,79.36 ; SW1.1 144.45,77.6 ; 72.77,2.98 J23.4 ; J23.4 73.5,3.71 ; J23.4 72.04,3.71 ; J23.4 72.77,4.44 ; SS7.1 138.67,63.06 ; SS7.1 136.49,60.88 ; SS7.1 134.31,63.06 ; SS7.1 136.49,65.24 ; J23.2 77.5,3.71 ; J23.2 76.77,4.44 ; J23.2 76.04,3.71 ; J23.2 76.77,2.98 ; 108.89,3.71 J25.4 ; J25.4 109.62,2.98 ; J25.4 110.34,3.71 ; J25.4 109.62,4.44 ; J26.4 99.4,3.71 ; J26.4 97.94,3.71 ; J26.4 98.67,4.44 ; J26.4 98.67,2.98 ; 145.52,74.55 SW2.3 ; SW2.3 146.4,75.43 ; SW2.3 147.28,74.55 ; SW2.3 146.4,73.67 ; 1.31,70.73 J21.3 ; J21.3 2.29,71.71 ; J21.3 2.29,69.76 ; J21.3 3.26,70.73 ; 112.29,60.88 SS8.1 ; SS8.1 112.29,65.24 ; SS8.1 110.11,63.06 ; SS8.1 114.47,63.06 ; J11.4 112.46,81.11 ; J11.4 112.46,79.65 ; J11.4 111.73,80.38 ; J11.4 113.19,80.38 ; J1.3 18.46,81.2 ; J1.3 18.46,78.15 ; J1.3 17.53,79.67 ; J1.3 19.39,79.67 ; SW3.3 146.4,69.94 ; SW3.3 146.4,68.19 ; SW3.3 145.52,69.06 ; SW3.3 147.28,69.06 ; J12.10 130.36,79.48 ; J12.10 129.38,78.5 ; J12.10 131.33,78.5 ; J12.10 130.36,77.52 ; 115.96,74.95 J11.16 ; J11.16 116.69,75.68 ; J11.16 115.23,75.68 ; J11.16 115.96,76.41 ; SS9.1 102.7,47.41 ; SS9.1 99.92,44.64 ; SS9.1 97.14,47.41 ; SS9.1 99.92,50.19 ; 47.08,6.05 J24.5 ; J24.5 48.16,7.13 ; J24.5 49.23,6.05 ; J24.5 48.16,4.97 ; SW1.3 146.4,80.91 ; SW1.3 145.52,80.03 ; SW1.3 147.28,80.03 ; SW1.3 146.4,79.15 ; J6.10 57.49,74.75 ; J6.10 56.51,73.77 ; J6.10 56.51,75.73 ; J6.10 55.53,74.75 ; J32.6 148.25,59.23 ; J32.6 147.27,60.21 ; J32.6 147.27,58.25 ; J32.6 146.29,59.23 ; 58.51,6.05 J24.2 ; J24.2 59.59,4.97 ; J24.2 60.66,6.05 ; J24.2 59.59,7.13 ; J11.7 116.69,78.88 ; J11.7 115.96,78.15 ; J11.7 115.23,78.88 ; J11.7 115.96,79.61 ; 68.77,2.98 J23.6 ; J23.6 68.77,4.44 ; J23.6 69.5,3.71 ; J23.6 68.04,3.71 ; J30.6 83.72,4.44 ; J30.6 83.72,2.98 ; J30.6 84.45,3.71 ; J30.6 82.99,3.71 ; 112.46,76.45 J11.13 ; J11.13 112.46,77.91 ; J11.13 113.19,77.18 ; J11.13 111.73,77.18 ; 144.45,66.64 SW3.1 ; SW3.1 145.33,67.51 ; SW3.1 144.45,68.39 ; SW3.1 143.57,67.51 ; J12.4 131.33,75.5 ; J12.4 130.36,76.48 ; J12.4 129.38,75.5 ; J12.4 130.36,74.52 ; J7.10 76.55,75.73 ; J7.10 77.53,74.75 ; J7.10 76.55,73.77 ; J7.10 75.57,74.75 ; SS6.1 46.7,13.41 ; SS6.1 41.14,13.41 ; SS6.1 43.92,16.19 ; SS6.1 43.92,10.64 ; 99.59,81.47 J33.2 100.17,80.9 ; 43.92,44.64 SS10.1 ; SS10.1 41.14,47.41 ; SS10.1 46.7,47.41 ; SS10.1 43.92,50.19 ; 37.61,57.04 J5.2 38.24,57.67 ; J32.14 147.27,50.05 ; J32.14 148.25,49.07 ; J32.14 146.29,49.07 ; J32.14 147.27,48.09 ; SS5.1 99.92,16.19 ; SS5.1 102.7,13.41 ; SS5.1 97.14,13.41 ; SS5.1 99.92,10.64
  ART03 w0.254: v1(63.96,0.79) v1(67.77,0.79) ; J33.11 97.84,75.69 ; J33.8 100.39,77.43 ; v1(3.91,56.06) 3.84,55.98 ; SS8.1 112.29,59.67 ; SS6.1 43.92,9.52 ; J33.5 97.8,79.15 ; 72.19,77.09 72.19,79.15 ; J33.17 97.83,72.22
  ART03 w0.508: 144.45,77.6 SW1.1 ; SW1.1 143.57,78.48 ; SW1.1 144.45,79.36 ; SW1.1 145.33,78.48 ; 1.31,70.73 J21.3 ; J21.3 2.29,69.76 ; J21.3 2.29,71.71 ; J21.3 3.26,70.73 ; 76.55,73.77 J7.10 ; J7.10 76.55,75.73 ; J7.10 75.57,74.75 ; J7.10 77.53,74.75 ; SW2.1 144.45,73.88 ; SW2.1 144.45,72.12 ; SW2.1 143.57,73 ; SW2.1 145.33,73 ; 60.66,6.05 J24.2 59.59,7.13 ; SW2.3 146.4,75.43 ; SW2.3 146.4,73.67 ; SW2.3 145.52,74.55 ; 143.75,54.15 J32.9 ; J32.9 145.71,54.15 ; J32.9 144.73,55.13 ; J12.4 130.36,76.48 ; J12.4 131.33,75.5 ; J12.4 129.38,75.5 ; J12.4 130.36,74.52 ; 115.23,78.88 J11.7 ; J11.7 116.69,78.88 ; J11.7 115.96,79.61 ; J11.7 115.96,78.15 ; 130.36,77.52 J12.10 ; J12.10 131.33,78.5 ; J12.10 130.36,79.48 ; J12.10 129.38,78.5 ; 48.16,4.97 J24.5 ; J24.5 48.16,7.13 ; J24.5 47.08,6.05 ; J24.5 49.23,6.05 ; SS7.1 136.49,65.24 ; SS7.1 138.67,63.06 ; SS7.1 136.49,60.88 ; SS7.1 134.31,63.06 ; 145.52,80.03 SW1.3 ; SW1.3 146.4,80.91 ; SW1.3 146.4,79.15 ; 18.46,78.15 J1.3 ; J1.3 19.39,79.67 ; J1.3 17.53,79.67 ; J1.3 18.46,81.2 ; SS8.1 112.29,65.24 ; SS8.1 114.47,63.06 ; SS8.1 110.11,63.06 ; J6.10 57.49,74.75 ; J6.10 56.51,73.77 ; J6.10 56.51,75.73 ; J6.10 55.53,74.75 ; J11.16 115.96,76.41 ; J11.16 115.96,74.95 ; J11.16 115.23,75.68 ; J11.16 116.69,75.68 ; J11.13 113.19,77.18 ; J11.13 112.46,76.45 ; J11.13 112.46,77.91 ; J11.13 111.73,77.18 ; 97.14,47.41 SS9.1 ; SS9.1 102.7,47.41 ; SS9.1 99.92,44.64 ; SS9.1 99.92,50.19 ; J26.4 98.67,4.44 ; J26.4 99.4,3.71 ; J26.4 98.67,2.98 ; J26.4 97.94,3.71 ; 12.24,79.67 J1.2 ; J1.2 13.16,78.15 ; J1.2 14.09,79.67 ; J1.2 13.16,81.2 ; SW3.1 145.33,67.51 ; SW3.1 143.57,67.51 ; SW3.1 144.45,66.64 ; SW3.1 144.45,68.39 ; 43.92,16.19 SS6.1 46.7,13.41 ; 111.73,80.38 J11.4 ; J11.4 112.46,79.65 ; J11.4 112.46,81.11 ; J11.4 113.19,80.38 ; SW3.3 146.4,69.94 ; SW3.3 146.4,68.19 ; SW3.3 145.52,69.06 ; 99.92,10.64 SS5.1 ; SS5.1 99.92,16.19 ; SS5.1 97.14,13.41 ; SS5.1 102.7,13.41 ; 99.59,81.47 J33.2 100.17,80.9
  ART04 w0.254: v1(94.56,73.79) 94.56,74.78 ; 97.84,75.69 J33.11 ; 72.26,77.32 72.26,79.17 ; J33.5 97.65,79.15 ; J33.8 100.44,77.43
  ART04 w0.508: J32.18 147.27,44.97 ; J32.18 148.25,43.99 ; J32.18 147.27,43.01 ; 1.31,70.73 J21.3 ; J21.3 2.29,71.71 ; J21.3 2.29,69.76 ; J21.3 3.26,70.73 ; 145.52,80.03 SW1.3 ; SW1.3 146.4,79.15 ; SW1.3 147.28,80.03 ; SW1.3 146.4,80.91 ; 148.25,59.23 J32.6 147.27,58.25 ; 99.59,81.47 J33.2 100.17,80.9 ; 147.27,48.09 J32.14 ; J32.14 148.25,49.07 ; J32.14 147.27,50.05 ; SW1.1 145.33,78.48 ; SW1.1 144.45,77.6 ; SW1.1 143.57,78.48 ; SW1.1 144.45,79.36 ; J7.10 76.55,75.73 ; J7.10 75.57,74.75 ; J7.10 77.53,74.75 ; J7.10 76.55,73.77 ; 56.51,73.77 J6.10 ; J6.10 56.51,75.73 ; J6.10 55.53,74.75 ; J6.10 57.49,74.75
  PWR05 w0.254: J33.17 97.57,72.22 ; J33.11 97.69,75.69 ; 72.21,76.89 72.21,79.3 ; J33.5 97.59,79.15 ; J33.8 100.58,77.43
  PWR05 w0.508: J30.6 84.45,3.71 ; J30.6 83.72,2.98 ; J30.6 83.72,4.44 ; J30.6 82.99,3.71 ; 47.08,6.05 J24.5 ; J24.5 48.16,7.13 ; J24.5 49.23,6.05 ; J24.5 48.16,4.97 ; SW3.3 146.4,69.94 ; SW3.3 145.52,69.06 ; SW3.3 146.4,68.19 ; SW3.3 147.28,69.06 ; J23.6 68.77,4.44 ; J23.6 68.77,2.98 ; J23.6 68.04,3.71 ; J23.6 69.5,3.71 ; 72.04,3.71 J23.4 ; J23.4 72.77,4.44 ; J23.4 73.5,3.71 ; J23.4 72.77,2.98 ; J32.18 147.27,44.97 ; J32.18 146.29,43.99 ; J32.18 147.27,43.01 ; J32.18 148.25,43.99 ; 144.73,53.17 J32.9 ; J32.9 145.71,54.15 ; J32.9 144.73,55.13 ; J32.9 143.75,54.15 ; 136.49,60.88 SS7.1 ; SS7.1 134.31,63.06 ; SS7.1 136.49,65.24 ; SS7.1 138.67,63.06 ; J2.2 38.82,62.21 ; J2.2 38.11,61.51 ; J2.2 38.11,62.92 ; J2.2 37.41,62.21 ; 145.52,80.03 SW1.3 ; SW1.3 146.4,79.15 ; SW1.3 147.28,80.03 ; SW1.3 146.4,80.91 ; 76.55,73.77 J7.10 ; J7.10 76.55,75.73 ; J7.10 77.53,74.75 ; J7.10 75.57,74.75 ; 97.14,47.41 SS9.1 ; SS9.1 99.92,44.64 ; SS9.1 99.92,50.19 ; SS9.1 102.7,47.41 ; 115.96,78.15 J11.7 ; J11.7 116.69,78.88 ; J11.7 115.96,79.61 ; J11.7 115.23,78.88 ; 97.94,3.71 J26.4 ; J26.4 99.4,3.71 ; J26.4 98.67,2.98 ; J26.4 98.67,4.44 ; SS5.1 102.7,13.41 ; SS5.1 99.92,16.19 ; SS5.1 97.14,13.41 ; SS5.1 99.92,10.64 ; J11.13 112.46,77.91 ; J11.13 112.46,76.45 ; J11.13 111.73,77.18 ; J11.13 113.19,77.18 ; J6.10 57.49,74.75 ; J6.10 56.51,75.73 ; J6.10 56.51,73.77 ; J6.10 55.53,74.75 ; J24.2 60.66,6.05 ; J24.2 59.59,7.13 ; J24.2 58.51,6.05 ; J24.2 59.59,4.97 ; 143.57,78.48 SW1.1 ; SW1.1 144.45,77.6 ; SW1.1 145.33,78.48 ; SW1.1 144.45,79.36 ; 43.92,44.64 SS10.1 ; SS10.1 46.7,47.41 ; SS10.1 43.92,50.19 ; SS10.1 41.14,47.41 ; J12.10 130.36,79.48 ; J12.10 129.38,78.5 ; J12.10 131.33,78.5 ; J12.10 130.36,77.52 ; SS8.1 114.47,63.06 ; SS8.1 110.11,63.06 ; SS8.1 112.29,65.24 ; SS8.1 112.29,60.88 ; J1.3 19.39,79.67 ; J1.3 18.46,81.2 ; J1.3 17.53,79.67 ; J1.3 18.46,78.15 ; 112.46,79.65 J11.4 ; J11.4 113.19,80.38 ; J11.4 111.73,80.38 ; J11.4 112.46,81.11 ; 76.04,3.71 J23.2 ; J23.2 76.77,4.44 ; J23.2 76.77,2.98 ; J23.2 77.5,3.71 ; 146.29,49.07 J32.14 ; J32.14 148.25,49.07 ; J32.14 147.27,48.09 ; J32.14 147.27,50.05 ; 147.27,58.25 J32.6 ; J32.6 148.25,59.23 ; J32.6 146.29,59.23 ; J32.6 147.27,60.21 ; J21.3 3.26,70.73 ; J21.3 2.29,71.71 ; J21.3 2.29,69.76 ; J21.3 1.31,70.73 ; SW3.1 145.33,67.51 ; SW3.1 144.45,68.39 ; SW3.1 144.45,66.64 ; SW3.1 143.57,67.51 ; J1.2 13.16,81.2 ; J1.2 12.24,79.67 ; J1.2 14.09,79.67 ; J1.2 13.16,78.15 ; 115.96,74.95 J11.16 ; J11.16 115.23,75.68 ; J11.16 116.69,75.68 ; J11.16 115.96,76.41 ; 129.38,75.5 J12.4 ; J12.4 131.33,75.5 ; J12.4 130.36,76.48 ; J12.4 130.36,74.52 ; SS6.1 46.7,13.41 ; SS6.1 43.92,16.19 ; SS6.1 41.14,13.41 ; SS6.1 43.92,10.64 ; J25.4 110.34,3.71 ; J25.4 108.89,3.71 ; J25.4 109.62,2.98 ; J25.4 109.62,4.44 ; SW2.1 145.33,73 ; SW2.1 144.45,72.12 ; SW2.1 144.45,73.88 ; SW2.1 143.57,73 ; 37.61,57.04 J5.2 38.24,57.67 ; 145.52,74.55 SW2.3 ; SW2.3 146.4,73.67 ; SW2.3 147.28,74.55 ; SW2.3 146.4,75.43 ; 100.17,80.9 J33.2 99.59,81.47
  BOTTOM w0.152: 84.18,52.2 84.02,52.04 84.02,51.51 84.28,51.26 ; 92.74,40.08 93.73,40.08
  BOTTOM w0.254: v1(96.64,76.48) 95.78,75.62 arc(95.65,75.43) 95.61,75.22 D43.1 93.29,74.93 v1(93.28,74.91) ; v1(118.87,12.37) v1(118.87,13.72) C139.2 ; R133.2 v1(123.44,62.2) ; v1(74.3,5.97) 74.44,6.11 arc(74.51,6.23) 74.54,6.36 C187.2 ; D45.1 v1(94.56,73.79) ; v1(62.64,11.18) 62.49,11.03 C184.2 ; R75.2 v1(91.97,82.69) ; U12.2 28.98,77.85 arc(29.16,77.93) 29.24,78.11 v1(29.24,79.1) 29.07,79.26 arc(28.98,79.4) 28.95,79.56 R120.2 28.95,80.54 29.06,80.64 v1(29.06,80.75) ; R78.2 v1(83.69,82.04) ; v1(133.35,20.57) 133.49,20.71 J4.6 ; C183.2 v1(66.81,5.99) ; J33.17 97.75,72.22 ; C30.2 v1(135.97,68.07) ; v1(110.09,87.49) L10.2 v1(108.6,87.49) ; v1(12.69,62.72) 12.67,62.74 R7.2 ; v1(92.57,71.33) C59.2 v1(92.57,72.94) ; R194.2 v1(94.36,7.62) 93.99,7.25 arc(93.61,7) 93.17,6.91 91.26,6.91 ; v1(129.29,9.3) 128.83,9.3 128.65,9.48 D38.1 ; D7.1 v1(130.76,16.26) ; U11.8 37.17,65.84 arc(37.08,65.83) 36.99,65.77 v1(36.88,65.66) ; C26.2 33.28,53.21 v1(33.5,53.21) ; v1(101.62,87.49) L27.1 v1(103.11,87.49) ; D2.1 v1(131.5,24.86) ; v1(75.31,58.97) 76.21,59.87 C56.2 ; C24.2 v1(37.34,51.13) ; J16.18 v1(5.45,15.35) ; R74.2 v1(91.97,87.49) ; C132.2 v1(129.16,85.75) ; v1(133.35,23.26) 132.14,23.26 arc(132.04,23.24) 131.96,23.19 D3.1 ; D13.1 v1(139.6,68.07) ; R55.2 v1(63.63,82.04) ; J33.11 97.79,75.69 ; v1(113.59,16.68) 113.59,15.5 arc(113.66,15.32) 113.84,15.25 R154.2 v1(114.3,13.72) ; v1(33.43,50.32) 33.4,50.32 arc(33.04,50.17) 32.89,49.81 C32.2 ; v1(58.8,54.13) 58.51,53.84 arc(58.23,53.65) 57.9,53.59 R16.2 ; D11.1 v1(139.6,71.37) ; v1(56.9,58.97) 57.67,59.74 C39.2 ; D8.1 v1(130.76,15.24) ; C25.2 v1(135.97,71.37) ; C156.2 8.69,24.77 ; v1(34.65,80.12) v1(33.66,80.12) 33.53,80 C94.2 ; D23.1 26.6,82.84 25.15,81.38 arc(24.98,81.27) 24.78,81.23 v1(24.51,81.23) 24.51,80.4 arc(24.54,80.27) 24.62,80.15 R123.2 ; v1(69.6,5.97) 69.74,6.11 arc(69.81,6.23) 69.84,6.36 C185.2 ; D46.1 101.8,68.07 arc(101.64,68.04) 101.5,67.95 v1(101.35,67.79) ; R86.2 v1(43.17,73.29) ; J15.21 v1(5.37,41.55) ; C27.2 v1(135.97,69.72) ; C155.2 8.69,25.78 ; R161.2 v1(120.9,13.72) ; R135.2 130.47,87.2 arc(130.58,87.12) 130.72,87.1 v1(130.91,87.1) ; 72.53,71.37 C43.2 v1(72.53,72.95) ; v1(47.5,62.23) 46.97,61.7 arc(46.84,61.62) 46.69,61.59 C80.2 ; 6.22,66.81 v1(6.22,65.81) ; 35.31,49.34 U6.1 v1(36.16,48.41) ; C85.2 v1(36.58,83.54) ; v1(114.5,87.07) 114.16,87.41 arc(114.07,87.47) 113.96,87.49 R125.2 ; C199.2 v1(32.51,10.63) ; C166.2 119.69,22.48 arc(119.54,22.45) 119.42,22.37 v1(118.71,21.66) ; D40.1 120.65,9.82 arc(120.69,9.64) 120.79,9.49 v1(121.06,9.22) ; R51.2 v1(73.05,87.49) ; v1(102.57,9.12) 102.39,9.31 arc(102.27,9.47) 102.23,9.67 D28.1 ; R178.2 v1(112.14,29.13) ; v1(63.6,40.58) v1(63.6,41.58) ; R124.2 v1(21.73,80.84) ; U27.2 v1(130.63,37.85) ; J17.18 v1(5.37,34.55) ; C148.2 v1(119.71,18.28) C138.2 ; C104.2 C103.2 25.79,81.06 v1(25.96,81.23) ; D6.1 v1(130.76,17.27) ; 72.19,76.94 72.19,79.1 ; v1(31.39,76.2) 31.61,76.2 C93.2 ; v1(77.77,8.97) 77.13,8.97 C188.2 ; C84.2 v1(43.18,72.26) ; v1(144.4,11.97) 143.44,12.93 v1(132.59,12.93) v1(130.39,12.93) v1(129.39,12.93) 129.38,12.93 v1(126.43,12.93) ; C168.2 v1(130.71,39.62) ; J33.5 97.8,79.15 ; C96.2 v1(34.88,65.66) ; C226.2 98.47,65.08 D48.2 99.44,64.29 v1(99.47,64.26) ; v1(127.3,20.52) 127.98,19.85 arc(128.09,19.68) 128.13,19.47 128.13,19.42 arc(128.18,19.21) 128.29,19.03 C20.2 129.26,19.01 arc(129.44,19.13) 129.65,19.18 129.96,19.18 arc(130.13,19.14) 130.28,19.04 130.56,18.76 arc(130.8,18.6) 131.09,18.54 C21.2 ; R2.2 19.56,63.75 v1(19.65,63.66) ; U5.4 v1(26.3,53.3) 25.94,53.67 arc(25.75,53.79) 25.52,53.84 C29.2 24.96,54.1 arc(24.71,54.27) 24.41,54.33 v1(22.33,54.33) v1(22.33,53.33) v1(22.33,52.33) v1(22.33,51.33) 22.35,51.31 v1(22.35,50.09) v1(23.35,50.09) v1(24.35,50.09) ; D12.1 v1(139.6,69.72) ; R101.2 v1(41.42,81.8) ; v1(130.63,35.76) 130.85,35.76 arc(131,35.79) 131.13,35.88 131.44,36.2 C169.2 ; C91.2 v1(34.88,68.33) ; C167.2 v1(128.07,38.35) ; U3.2 v1(51.44,13.39) ; C28.2 v1(26.14,50.81) ; C146.2 v1(125.48,13.87) ; R50.2 v1(71.39,82.69) ; D39.1 v1(123.44,9.22) ; U25.2 v1(123.19,13.72) ; U13.2 v1(116.08,84.58) ; U11.9 37.16,66.34 ; v1(99.78,9.12) 99.59,9.31 arc(99.48,9.47) 99.44,9.67 D27.1 ; U24.2 v1(116.59,13.72) ; 80.06,51.38 80.06,52.3 ; U20.2 v1(132.46,84.58) ; D29.1 105.03,9.67 arc(105.07,9.47) 105.18,9.31 v1(105.37,9.12) ; J33.8 100.4,77.43 ; J14.21 v1(7.75,22.35) ; C61.2 v1(72.77,66.04) ; R176.2 v1(111,29.13) ; 132.28,27.05 v1(132.23,27.1) ; J16.24 v1(5.45,12.35) ; Q17.2 v1(93.15,8.97)
  BOTTOM w0.305: R137.1 80.39,47.24 v1(80.37,47.27)
  BOTTOM w0.508: 82.99,3.71 J30.6 ; J30.6 84.45,3.71 ; J30.6 83.72,4.44 ; J11.7 115.96,79.61 ; J11.7 115.96,78.15 ; J11.7 115.23,78.88 ; J11.7 116.69,78.88 ; 68.04,3.71 J23.6 69.5,3.71 ; 148.4,27.16 J19.11 ; J19.11 148.4,28.52 ; J19.11 147.17,27.84 ; 13.16,78.15 J1.2 ; J1.2 13.16,81.2 ; J1.2 12.24,79.67 ; J1.2 14.09,79.67 ; J7.10 76.55,75.73 ; J7.10 77.53,74.75 ; J7.10 76.55,73.77 ; J7.10 75.57,74.75 ; 147.27,48.09 J32.14 ; J32.14 146.29,49.07 ; J32.14 148.25,49.07 ; J32.14 147.27,50.05 ; 38.11,61.51 J2.2 37.41,62.21 ; J4.13 136.56,10.61 ; J4.13 134.42,10.61 ; J4.13 135.49,9.54 ; SW3.1 144.45,68.39 ; SW3.1 143.57,67.51 ; SW3.1 145.33,67.51 ; SW3.1 144.45,66.64 ; 144.45,77.6 SW1.1 ; SW1.1 143.57,78.48 ; SW1.1 144.45,79.36 ; SW1.1 145.33,78.48 ; 147.27,58.25 J32.6 ; J32.6 147.27,60.21 ; J32.6 148.25,59.23 ; 111.73,77.18 J11.13 ; J11.13 113.19,77.18 ; J11.13 112.46,77.91 ; 2.29,69.76 J21.3 ; J21.3 2.29,71.71 ; J21.3 3.26,70.73 ; J21.3 1.31,70.73 ; 47.08,6.05 J24.5 ; J24.5 48.16,4.97 ; J24.5 49.23,6.05 ; J24.5 48.16,7.13 ; 3.86,46.02 J15.25 ; J15.25 5.2,44.75 ; J15.25 3.86,43.46 ; 143.75,54.15 J32.9 ; J32.9 144.73,53.17 ; J32.9 144.73,55.13 ; J24.2 59.59,7.13 ; J24.2 60.66,6.05 ; J24.2 58.51,6.05 ; J24.2 59.59,4.97 ; SS6.1 43.92,16.19 ; SS6.1 46.7,13.41 ; SS6.1 41.14,13.41 ; SS6.1 43.92,10.64 ; 144.45,72.12 SW2.1 ; SW2.1 143.57,73 ; SW2.1 145.33,73 ; SW2.1 144.45,73.88 ; SS10.1 46.7,47.41 ; SS10.1 43.92,50.19 ; SS10.1 43.92,44.64 ; SS10.1 41.14,47.41 ; 148.4,40.16 J19.10 ; J19.10 148.4,41.52 ; J19.10 147.17,40.84 ; J12.4 130.36,76.48 ; J12.4 131.33,75.5 ; J12.4 129.38,75.5 ; J12.4 130.36,74.52 ; 2.68,10.65 J14.26 ; J14.26 5.04,10.65 ; J14.26 3.86,11.63 ; J14.26 3.86,9.67 ; J14.25 5.28,25.55 ; J14.25 3.86,24.24 ; J14.25 2.47,25.55 ; J26.4 98.67,4.44 ; J26.4 98.67,2.98 ; J26.4 99.4,3.71 ; J26.4 97.94,3.71 ; 145.09,24.27 J4.11 ; J4.11 145.09,26.15 ; J4.11 143.71,25.21 ; J19.8 137.63,40.84 ; J19.8 135.17,40.84 ; J19.8 136.4,40.16 ; J19.8 136.4,41.52 ; 136.4,27.16 J19.9 ; J19.9 137.63,27.84 ; J19.9 135.17,27.84 ; J19.9 136.4,28.52 ; 115.23,75.68 J11.16 ; J11.16 115.96,74.95 ; J11.16 115.96,76.41 ; J11.16 116.69,75.68 ; 110.11,63.06 SS8.1 ; SS8.1 114.47,63.06 ; SS8.1 112.29,65.24 ; SS8.1 112.29,60.88 ; 129.38,78.5 J12.10 ; J12.10 131.33,78.5 ; J12.10 130.36,79.48 ; J12.10 130.36,77.52 ; 109.62,2.98 J25.4 ; J25.4 109.62,4.44 ; J25.4 110.34,3.71 ; J25.4 108.89,3.71 ; 99.59,81.47 J33.2 100.17,80.9 ; 97.14,47.41 SS9.1 ; SS9.1 99.92,44.64 ; SS9.1 102.7,47.41 ; SS9.1 99.92,50.19 ; J15.26 3.86,28.7 ; J15.26 5.28,29.85 ; J15.26 3.86,30.96 ; 55.53,74.75 J6.10 ; J6.10 56.51,75.73 ; J6.10 57.49,74.75 ; J6.10 56.51,73.77 ; SS7.1 138.67,63.06 ; SS7.1 136.49,65.24 ; SS7.1 134.31,63.06 ; SS7.1 136.49,60.88 ; J11.4 113.19,80.38 ; J11.4 111.73,80.38 ; J11.4 112.46,81.11 ; 77.5,3.71 J23.2 76.77,4.44 ; 134.42,25.21 J4.10 136.56,25.21 ; 146.4,80.91 SW1.3 147.28,80.03 ; 17.53,79.67 J1.3 ; J1.3 19.39,79.67 ; J1.3 18.46,81.2 ; J1.3 18.46,78.15 ; 143.71,9.71 J4.12 ; J4.12 145.09,8.77 ; J4.12 145.09,10.65 ; SS5.1 102.7,13.41 ; SS5.1 97.14,13.41 ; SS5.1 99.92,16.19 ; 146.29,43.99 J32.18 ; J32.18 147.27,43.01 ; J32.18 147.27,44.97 ; J32.18 148.25,43.99 ; 72.04,3.71 J23.4 ; J23.4 73.5,3.71 ; J23.4 72.77,4.44
  vias: v1(0.82,87.38) v1(0.79,83.57) v1(0.79,79.76) v1(0.79,75.95) v1(0.79,72.14) v1(0.79,68.33) v1(0.79,64.52) v1(0.79,60.71) v1(0.79,59.44) v1(0.79,58.17) v1(0.79,56.9) v1(0.79,55.63) v1(0.79,54.36) v1(0.79,53.09) v1(0.79,51.82) v1(0.79,50.55) v1(0.79,49.28) v1(0.79,26.42) v1(0.79,22.61) v1(0.79,21.34) v1(0.79,20.07) v1(0.79,18.8) v1(0.79,17.53) v1(0.79,16.26) v1(0.79,14.99) v1(0.79,7.37) v1(1.22,65.81) v1(2.22,65.81) v1(2.16,20.07) v1(2.18,13.34) v1(2.29,23.35) v1(2.29,22.35) v1(2.29,16.09) v1(2.5,61.87) v1(2.67,58.09) v1(3,0.79) v1(3.15,46.56) v1(3.22,65.81) v1(3.28,36.73) v1(3.29,35.29) v1(3.3,20.75) v1(3.29,16.09) v1(3.42,55.14) v1(3.37,52.87) v1(3.37,51.87) v1(3.37,42.55) v1(3.37,40.55) v1(3.37,31.55) v1(3.35,17.98) v1(3.5,61.87) v1(3.56,23.35) v1(3.56,22.35) v1(3.67,58.09) v1(4.22,65.81) v1(4.31,80.78) v1(4.45,77.85) v1(4.45,76.58) v1(4.45,75.31) v1(4.45,74.04) v1(4.37,52.87) v1(4.37,42.55) v1(4.37,41.55) v1(4.37,32.55) v1(4.37,31.55) v1(4.45,13.35) v1(4.45,12.35) v1(4.5,61.87) v1(4.6,46.58) v1(4.56,23.35) v1(4.56,22.35) v1(5,72.09) v1(5,71.09) v1(5,70.09) v1(5,69.09) v1(5.22,65.81) v1(5.31,80.78) v1(5.37,42.55) v1(5.41,38.91) v1(5.45,14.35) v1(5.5,57.87) v1(5.5,56.87) v1(5.46,17.55) v1(5.61,10.54) v1(6.31,80.78) v1(6.38,7.9) v1(6.6,77.72) v1(6.69,24.77) v1(6.81,0.79) v1(7.31,80.78) v1(7.31,74.09) v1(7.31,73.09) v1(7.31,72.09) v1(7.31,71.09) v1(7.31,69.09) v1(7.62,61.37) v1(7.62,60.37) v1(7.59,44.04) v1(7.67,48.9) v1(7.67,47.89) v1(7.75,41.55) v1(7.69,24.77) v1(7.75,18.35) v1(7.97,89.21) v1(8.31,74.09) v1(8.31,73.09) v1(8.31,72.09) v1(8.31,71.09) v1(8.31,70.09) v1(8.31,69.09) v1(8.31,68.09) v1(8.31,67.09) v1(8.59,44.04) v1(8.67,61.72) v1(8.67,60.72) v1(8.67,55.72) v1(8.67,54.72) v1(8.67,48.9) v1(8.67,47.89) v1(8.94,18.59) v1(9.1,63.72) v1(9.22,22.35) v1(9.31,69.09) v1(9.31,68.09) v1(9.31,67.09) v1(9.67,53.72) v1(10.62,0.79) v1(10.67,53.72) v1(10.67,52.72) v1(10.98,40.82) v1(10.97,38.4) v1(11.11,34.21) v1(11.13,26.75) v1(11.78,89.21) v1(11.85,18.33) v1(11.85,17.06) v1(11.9,15.06) v1(11.98,39.82) v1(12.11,34.21) v1(12.55,44.75) v1(12.62,22.23) v1(12.62,20.95) v1(12.7,14.83) v1(12.7,13.56) v1(12.8,39.19) v1(13.11,34.21) v1(13.26,47.28) v1(13.41,36.4) v1(13.46,41.88) v1(13.49,30.51) v1(13.65,75.66) v1(13.67,63.72) v1(13.67,62.72) v1(13.67,56.72) v1(13.67,55.72) v1(13.67,54.72) v1(13.7,13.56) v1(13.96,10.54) v1(13.96,9.54) v1(14.11,34.21) v1(14.41,36.4) v1(14.43,0.79) v1(14.65,75.66) v1(14.69,62.72) v1(14.67,56.72) v1(14.67,55.72) v1(14.67,54.72) v1(14.7,13.56) v1(14.79,68.78) v1(14.79,67.78) v1(14.79,66.78) v1(14.89,18.67) v1(15.11,34.21) v1(15.46,38.99) v1(15.59,89.21) v1(15.65,75.66) v1(15.65,74.66) v1(15.65,73.66) v1(15.67,53.72) v1(15.67,52.72) v1(15.79,68.78) v1(15.89,18.67) v1(16.11,34.21) v1(16.21,10.54) v1(16.21,9.54) v1(16.43,16.38) v1(16.48,43.69) v1(16.46,40.26) v1(16.65,73.66) v1(16.67,53.72) v1(16.67,52.72) v1(16.79,68.78) v1(16.89,42.14) v1(17.27,45.01) v1(17.65,75.66) v1(17.65,74.66) v1(17.65,73.66) v1(17.65,72.66) v1(18.03,43.05) v1(17.96,41.22) v1(18.24,0.79) v1(18.52,13.08) v1(18.52,10.54) v1(18.52,9.27) v1(18.65,75.66) v1(18.65,74.66) v1(18.65,73.66) v1(18.65,72.66) v1(18.65,62.66) v1(18.72,21.97) v1(18.8,24.64) v1(19.02,44.37) v1(19.17,36.31) v1(19.2,33.91) v1(19.4,89.21) v1(19.65,72.66) v1(19.65,69.66) v1(19.65,64.66) v1(19.79,14.35) v1(19.79,13.08) v1(20.06,76.5) v1(20.1,37.51) v1(20.2,33.91) v1(20.34,85.04) v1(20.34,84.04) v1(20.65,72.66) v1(20.65,69.66) v1(20.65,68.66) v1(20.65,67.66) v1(20.65,66.66) v1(20.65,65.66) v1(20.65,64.66) v1(20.65,63.66) v1(20.65,62.66) v1(20.65,61.66) v1(20.65,60.66) v1(20.65,59.66) v1(20.75,79.99) v1(21.1,37.51) v1(21.13,36.32) v1(21.34,84.04) v1(21.73,77.16) v1(21.65,72.66) v1(21.65,69.66) v1(21.65,68.66) v1(21.65,67.66) v1(21.65,66.66) v1(21.65,65.66) v1(21.65,64.66) v1(21.65,63.66) v1(21.65,62.66) v1(21.65,61.66) v1(21.65,60.66) v1(21.65,59.66) v1(21.77,75.31) v1(22.05,0.79) v1(22.94,85.42) v1(22.99,18.67) v1(23.36,23.58) v1(24,46.14) v1(24.51,76.2) v1(24.46,67.6) v1(24.51,63.91) v1(24.51,62.91) v1(24.51,61.91) v1(24.59,82.85) v1(24.92,31.45) v1(25.07,10.54) v1(25.07,9.27) v1(25.36,87.39) v1(25.51,63.91) v1(25.51,62.91) v1(25.51,61.91) v1(25.7,32.66) v1(25.86,0.79) v1(26.16,26.95) v1(26.31,76.2) v1(26.3,54.3) v1(26.36,88.19) v1(26.6,38.6) v1(26.6,37.71) v1(26.7,19) v1(26.7,15.47) v1(26.67,14.05) v1(26.89,21.97) v1(27.15,76.17) v1(27.18,50.7) v1(27.28,32.94) v1(27.76,25.27) v1(27.97,72.64) v1(27.97,67.64) v1(27.97,66.64) v1(27.97,65.64) v1(27.97,64.64) v1(27.97,63.64) v1(27.97,62.64) v1(27.97,61.64) v1(27.97,60.64) v1(27.97,56.59) v1(28.14,9.96) v1(28.32,29.26) v1(28.6,76.17) v1(28.83,49.66) v1(28.87,52.92) v1(28.87,51.92) v1(28.88,44.96) v1(28.96,88.21) v1(28.96,56.59) v1(29.2,37.99) v1(29.2,35.1) v1(29.6,76.17) v1(29.59,28.02) v1(29.67,0.79) v1(29.79,4.22) v1(29.88,44.96) v1(30.3,67.6) v1(30.35,63.91) v1(30.35,62.91) v1(30.35,61.91) v1(30.35,35.99) v1(30.48,8.74) v1(30.8,87.39) v1(30.88,44.96) v1(30.93,33.37) v1(30.91,26.87) v1(31.09,83.34) v1(31.24,10.57) v1(31.37,82.25) v1(31.35,63.91) v1(31.35,62.91) v1(31.35,61.91) v1(31.42,35.99) v1(31.85,18.72) v1(32.05,33.38) v1(32.56,21.97) v1(32.92,85.37) v1(32.91,31.75) v1(32.91,30.75) v1(33.02,38.15) v1(33.12,4.22) v1(33.32,26.87) v1(33.48,54.91) v1(33.48,0.79) v1(33.56,21.97) v1(33.66,77.12) v1(33.78,18.97) v1(33.78,14.94) v1(33.78,13.67) v1(33.93,32.79) v1(33.96,37.08) v1(33.96,35.43) v1(34.06,75.29) v1(34.15,59.99) v1(34.29,63.5) v1(34.64,89.21) v1(34.56,83.54) v1(34.56,82.54) v1(34.59,50.32) v1(34.59,26.87) v1(34.56,21.97) v1(34.57,9.73) v1(35,72.36) v1(35.15,71.12) v1(35.56,85.54) v1(35.56,84.54) v1(35.61,62.36) v1(35.61,60.83) v1(35.61,59.83) v1(35.64,34.42) v1(35.6,33.26) v1(35.6,32.39) v1(35.89,50.34) v1(35.91,29.85) v1(35.86,26.87) v1(36.2,9.63) v1(37.13,26.87) v1(37.2,31.31) v1(37.18,29.85) v1(37.29,0.79) v1(37.41,73.69) v1(37.36,33.58) v1(37.59,59.44) v1(37.64,54.88) v1(37.62,53.95) v1(37.97,80.57) v1(38.18,36.17) v1(38.45,29.85) v1(38.4,26.87) v1(38.35,9.63) v1(38.45,89.21) v1(38.56,21.97) v1(38.68,76.23) v1(38.68,74.96) v1(38.68,73.69) v1(38.94,66.45) v1(39.37,9.63) v1(39.72,29.85) v1(39.67,26.87) v1(39.78,54.89) v1(40.21,68.5) v1(40.28,80.57) v1(40.46,76.23) v1(40.46,74.96) v1(40.46,73.69) v1(40.49,31.55) v1(40.89,59.51) v1(40.92,54.89) v1(40.94,26.87) v1(41.12,67.5) v1(41.12,3.89) v1(41.1,0.79) v1(41.2,61.54) v1(41.48,36.17) v1(41.53,30.25) v1(41.88,58.57) v1(42.26,89.21) v1(42.62,62.05) v1(42.6,60.07) v1(42.56,22.97) v1(43.18,85.72) v1(43.18,84.45) v1(43.18,83.19) v1(43.18,81.92) v1(43.18,80.64) v1(43.18,79.38) v1(43.18,78.11) v1(43.18,76.83) v1(43.18,75.56) v1(43.31,19.05) v1(43.64,67.64) v1(43.66,59) v1(44.91,40.21) v1(44.88,36.17) v1(44.85,30.25) v1(44.91,0.79) v1(44.96,57.78) v1(44.96,55.09) v1(45.9,9.18) v1(46.07,89.21) v1(46.43,50.65) v1(46.35,36.17) v1(46.74,76.33) v1(46.85,29.25) v1(46.85,28.25) v1(46.9,9.18) v1(47.37,22.91) v1(47.5,63.23) v1(47.85,27.25) v1(47.9,9.18) v1(48.12,17.51) v1(48.12,16.51) v1(48.72,0.79) v1(48.84,63.58) v1(48.77,22.5) v1(48.85,27.25) v1(48.9,11.18) v1(48.97,66.98) v1(49.12,17.51) v1(49.12,16.51) v1(49.28,74.68) v1(49.25,72.29) v1(49.88,89.21) v1(49.92,78.87) v1(49.92,77.6) v1(49.92,76.33) v1(49.9,11.18) v1(49.9,10.18) v1(50.12,17.51) v1(50.12,16.51) v1(50.62,58.78) v1(50.75,27.03) v1(50.92,51.79) v1(50.9,11.18) v1(50.9,10.18) v1(50.9,9.18) v1(51.26,54.86) v1(51.44,15.39) v1(51.56,51.08) v1(51.9,11.18) v1(51.9,10.18) v1(51.9,9.18) v1(51.97,66.98) v1(52.53,0.79) v1(52.9,11.18) v1(52.9,10.18) v1(52.9,9.18) v1(52.97,66.98) v1(53.16,75.41) v1(53.42,83.26) v1(53.42,81.99) v1(53.42,80.72) v1(53.69,89.21) v1(53.92,40.21) v1(53.92,36.17) v1(53.92,31.39) v1(54.28,53.39) v1(54.36,14.05) v1(54.36,13.05) v1(54.92,51.79) v1(55.67,26.99) v1(55.79,56.58) v1(55.92,44.11) v1(55.92,43.11) v1(55.9,10.18) v1(55.9,9.18) v1(56.34,0.79) v1(56.42,68.87) v1(56.79,56.58) v1(56.84,40.21) v1(56.9,66.29) v1(56.92,43.11) v1(56.92,42.11) v1(56.92,36.17) v1(56.9,9.18) v1(57,54.38) v1(57.5,89.21) v1(57.67,27.99) v1(57.84,40.21) v1(57.92,51.79) v1(57.92,42.11) v1(57.96,13.89) v1(58.19,36.17) v1(58.57,27) v1(58.92,51.79) v1(58.92,50.79) v1(59.13,80.92) v1(59.36,13.89) v1(59.53,64.08) v1(59.53,62.81) v1(59.53,61.54) v1(59.46,36.17) v1(60.15,0.79) v1(60.63,83.04) v1(60.63,82.04) v1(60.8,64.08) v1(60.8,62.81) v1(60.8,61.54) v1(60.92,42.11) v1(61.31,89.21) v1(61.63,83.04) v1(61.63,82.04) v1(61.95,47.2) v1(62.07,64.08) v1(62.07,62.81) v1(62.07,61.54) v1(62.36,3.23) v1(62.63,83.04) v1(62.63,82.04) v1(62.87,47.19) v1(63.18,66.75) v1(63.63,83.04) v1(63.96,68.88) v1(64.18,66.75) v1(64.85,56.57) v1(65,80.92) v1(65.12,89.21) v1(65.23,68.88) v1(65.18,66.75) v1(65.84,63.2) v1(65.81,6.99) v1(65.81,5.99) v1(65.94,57.78) v1(66.12,11.18) v1(66.17,56.77) v1(66.85,36.17) v1(67.12,11.18) v1(67.23,26.54) v1(67.26,24.1) v1(67.36,47.17) v1(67.83,68.87) v1(68.12,11.18) v1(68.23,26.54) v1(68.4,36.18) v1(68.55,7.97) v1(68.83,68.87) v1(68.93,89.21) v1(68.92,44.11) v1(68.92,43.11) v1(68.92,42.11) v1(68.94,13.26) v1(69.12,11.18) v1(69.23,26.54) v1(69.55,36.17) v1(69.83,68.87) v1(69.76,54.86) v1(70.05,59.74) v1(70.46,51) v1(70.61,10.16) v1(70.6,5.97) v1(70.83,68.87) v1(70.82,36.17) v1(71.05,59.74) v1(71.63,57.78) v1(71.63,11.99) v1(71.6,5.97) v1(71.58,0.79) v1(71.83,68.87) v1(72.09,36.17) v1(72.74,89.21) v1(72.83,68.87) v1(73.24,9.97) v1(73.31,64.02) v1(73.36,36.17) v1(73.53,72.95) v1(73.98,26.54) v1(74.07,48.11) v1(74.07,47.11) v1(74.07,46.11) v1(74.07,45.11) v1(74.07,44.11) v1(74.07,43.11) v1(74.72,22.51) v1(74.72,21.51) v1(74.83,68.87) v1(74.98,26.54) v1(75.23,12.8) v1(75.31,66.29) v1(75.29,5.97) v1(75.39,0.79) v1(75.72,11.18) v1(76.55,89.21) v1(76.61,38.68) v1(77.77,7.65) v1(78.08,64.03) v1(78.08,62.76) v1(78.08,61.49) v1(79.2,0.79) v1(79.35,64.03) v1(79.35,62.76) v1(79.35,61.49) v1(79.65,26.54) v1(79.73,21.51) v1(79.98,80.59) v1(80.36,89.21) v1(80.47,40.28) v1(80.62,64.03) v1(80.62,62.76) v1(80.62,61.49) v1(80.64,8.97) v1(80.69,83.04) v1(80.69,82.04) v1(81.69,83.04) v1(81.69,82.04) v1(81.84,65.71) v1(82.5,68.71) v1(82.69,83.04) v1(82.69,82.04) v1(82.7,8.92) v1(83.01,0.79) v1(83.69,83.04) v1(83.68,8.92) v1(83.77,68.71) v1(84.17,89.21) v1(84.28,35.51) v1(84.25,26.52) v1(84.56,63.17) v1(85.01,80.62) v1(85.04,68.71) v1(86.52,44.38) v1(86.52,43.11) v1(86.59,35.51) v1(86.72,26.52) v1(86.82,0.79) v1(87.25,68.71) v1(87.86,35.51) v1(87.98,89.21) v1(88.17,54.86) v1(88.6,67.97) v1(88.67,57.07) v1(89.13,35.51) v1(89.15,53.42) v1(90.27,61.4) v1(90.27,60.4) v1(90.37,40.28) v1(90.4,35.51) v1(90.63,0.79) v1(90.84,67.96) v1(90.86,66.34) v1(91.01,7.32) v1(91.06,85.67) v1(91.06,84.23) v1(91.15,8.97) v1(91.64,13.87) v1(91.67,35.51) v1(91.79,89.21) v1(92.18,45.77) v1(92.15,8.97) v1(92.33,44.3) v1(92.33,43.03) v1(92.33,41.73) v1(92.35,40.36) v1(92.52,49.79) v1(92.61,61.39) v1(92.72,17.51) v1(92.72,16.51) v1(92.72,11.18) v1(92.94,35.51) v1(93.12,68.66) v1(93.55,53.42) v1(93.73,63.86) v1(93.72,19.51) v1(93.72,11.18) v1(94.16,60.4) v1(94.44,0.79) v1(94.52,51.79) v1(94.49,40.34) v1(94.56,72.06) v1(94.56,68.96) v1(94.64,47.17) v1(94.92,76.81) v1(94.95,61.39) v1(95.52,51.79) v1(95.53,41.22) v1(95.48,35.51) v1(95.6,89.21) v1(95.75,67.79) v1(95.71,44.15) v1(95.96,53.42) v1(96.64,75.48) v1(96.6,61.39) v1(96.75,35.51) v1(96.88,72.29) v1(97.5,33.27) v1(97.5,32.16) v1(97.5,29.08) v1(97.92,61.39) v1(98.02,35.51) v1(98.22,69.85) v1(98.22,66.78) v1(98.25,0.79) v1(98.5,31.08) v1(98.5,30.03) v1(98.5,29.08) v1(98.5,26.52) v1(98.58,85.45) v1(99.29,35.51) v1(99.29,33.99) v1(99.41,89.21) v1(99.85,85.45) v1(100.22,59.43) v1(100.35,67.79) v1(100.28,61.4) v1(100.43,31.75) v1(100.52,19.53) v1(100.56,35.51) v1(100.66,27.51) v1(100.84,74.32) v1(100.84,73.05) v1(101.12,85.45) v1(101.27,77.42) v1(101.55,22.68) v1(101.57,37.13) v1(101.83,35.51) v1(102.06,0.79) v1(102.29,33.3) v1(102.52,19.53) v1(103.1,35.51) v1(103.22,89.21) v1(103.2,61.4) v1(103.43,79.96) v1(103.35,39.01) v1(103.54,66.82) v1(103.87,68.12) v1(104.06,21.68) v1(104.06,20.68) v1(104.06,19.68) v1(104.09,15.42) v1(104.16,11.12) v1(104.37,61.4) v1(104.37,60.4) v1(104.54,77.43) v1(104.9,35.51) v1(105.03,28.44) v1(105.21,74.52) v1(105.23,70.82) v1(105.37,26.68) v1(105.37,25.68) v1(105.66,79.96) v1(105.87,0.79) v1(106.03,28.44) v1(106.07,56.7) v1(106.15,39.04) v1(106.17,37.59) v1(106.16,11.12) v1(106.37,26.68) v1(106.38,7.34) v1(106.53,75.79) v1(106.5,72.31) v1(106.5,68.43) v1(106.58,33.35) v1(107.03,89.21) v1(107.03,28.44) v1(107.16,15.12) v1(107.16,14.12) v1(107.16,11.12) v1(107.31,62.19) v1(107.29,59.59) v1(107.37,26.68) v1(108.05,73.15) v1(108.16,16.12) v1(108.16,15.12) v1(108.16,14.12) v1(108.15,3.25) v1(108.37,26.68) v1(108.37,25.68) v1(108.37,21.68) v1(108.37,20.68) v1(109.07,60.25) v1(109.07,58.98) v1(109.07,57.71) v1(109.07,56.44) v1(109.07,55.17) v1(109.07,48.41) v1(109.07,47.14) v1(109.07,45.87) v1(109.07,44.6) v1(109.07,38.89) v1(109.07,37.62) v1(109.07,36.35) v1(109.32,73.15) v1(109.37,26.68) v1(109.68,0.79) v1(110.37,21.68) v1(110.37,20.68) v1(110.53,18.28) v1(110.59,73.15) v1(110.84,89.21) v1(110.92,55.51) v1(110.92,54.51) v1(111.14,67.79) v1(111.37,20.68) v1(111.86,73.15) v1(111.92,55.51) v1(111.92,54.51) v1(111.95,8.39) v1(111.95,7.39) v1(112.14,26.67) v1(112.37,20.68) v1(112.47,51.16) v1(112.47,49.73) v1(112.92,55.51) v1(112.92,54.51) v1(113.14,26.67) v1(113.16,39.14) v1(113.18,33.34) v1(113.44,45.11) v1(113.49,0.79) v1(113.61,21.68) v1(113.77,67.79) v1(113.92,58.32) v1(113.92,57.05) v1(113.92,55.78) v1(113.92,54.51) v1(114.25,39.15) v1(114.18,33.34) v1(114.16,29.16) v1(114.16,28.16) v1(114.16,27.16) v1(114.38,85.34) v1(114.6,50.1) v1(114.61,20.68) v1(114.65,89.21) v1(114.71,45.11) v1(114.83,74.47) v1(114.76,66.07) v1(114.99,8.45) v1(114.99,6.22) v1(115.25,39.15) v1(115.18,33.34) v1(115.49,50.1) v1(115.65,73.03) v1(115.59,13.72) v1(115.98,45.11) v1(116.01,29.03) v1(116.01,28.03) v1(116.01,27.03) v1(116.08,83.58) v1(116.05,67.74) v1(116.1,12.34) v1(116.25,39.15) v1(116.18,33.34) v1(116.61,20.65) v1(116.66,63.51) v1(117.01,29.03) v1(117.01,28.03) v1(117.01,27.03) v1(117.08,84.58) v1(117.08,83.58) v1(117.12,74.47) v1(117.09,9.4) v1(117.09,7.92) v1(117.09,6.43) v1(117.25,39.15) v1(117.25,38.15) v1(117.18,33.34) v1(117.27,3.89) v1(117.3,0.79) v1(117.58,20.65) v1(117.59,13.72) v1(117.87,12.37) v1(118.01,50.09) v1(118.01,29.03) v1(118.01,28.03) v1(118.01,27.03) v1(118.08,84.58) v1(118.08,83.58) v1(118.09,6.43) v1(118.16,67.79) v1(118.25,37.15) v1(118.46,89.21) v1(118.64,61.06) v1(118.71,20.66) v1(119.01,29.03) v1(119.01,28.03) v1(119.01,27.03) v1(119.25,37.15) v1(119.25,44.88) v1(119.46,89.21) v1(119.71,17.28) v1(120.01,29.03) v1(120.01,28.03) v1(120.01,27.03) v1(120.12,51.18) v1(120.42,73.69) v1(120.42,6.73) v1(120.46,89.21) v1(120.46,88.21) v1(120.46,87.21) v1(120.52,37.15) v1(120.62,70) v1(120.68,67.79) v1(121.01,29.03) v1(121.01,28.03) v1(121.01,27.03) v1(121.23,72.01) v1(121.62,25.76) v1(121.69,73.69) v1(121.69,6.73) v1(121.9,13.72) v1(122.1,65.81) v1(122.12,61.39) v1(122.27,89.21) v1(122.31,28.03) v1(122.31,27.03) v1(122.71,20.66) v1(122.94,44.91) v1(122.96,73.69) v1(123.04,33.34) v1(123.44,63.47) v1(123.67,51.21) v1(124.13,56.95) v1(124.21,44.91) v1(124.19,13.72) v1(124.31,72.47) v1(124.44,9.22) v1(124.69,7.39) v1(125.44,9.22) v1(125.48,64.74) v1(125.48,63.47) v1(125.48,62.2) v1(125.45,57.38) v1(125.45,53.9) v1(125.58,72.47) v1(125.69,7.39) v1(126.08,89.21) v1(126.08,88.21) v1(126.08,87.21) v1(126.18,40.6) v1(126.18,39.6) v1(126.18,38.6) v1(126.44,9.22) v1(126.53,51.21) v1(126.62,66.01) v1(126.62,64.77) v1(126.62,63.5) v1(126.62,62.23) v1(126.69,7.39) v1(126.69,6.39) v1(126.85,72.47) v1(127.08,89.21) v1(127.08,88.21) v1(127.84,14.61) v1(128.12,72.47) v1(128.07,40.62) v1(128.27,64.11) v1(128.27,63.11) v1(128.27,62.11) v1(129.03,51.23) v1(129.03,50.23) v1(129.06,42.9) v1(129.07,40.62) v1(129.31,69.6) v1(129.29,58.59) v1(129.39,32.08) v1(129.44,30.15) v1(129.63,34.76) v1(129.59,6.39) v1(129.89,89.21) v1(130.06,42.9) v1(130.07,40.62) v1(130.3,52.93) v1(130.3,51.23) v1(130.25,27.1) v1(130.53,73.28) v1(130.58,48.95) v1(130.76,85.39) v1(130.76,30.15) v1(131.11,70.31) v1(131.32,68.04) v1(131.3,52.93) v1(132.07,59.06) v1(132.07,57.03) v1(132.05,55.37) v1(132.21,31.1) v1(132.41,72.34) v1(132.41,71.07) v1(132.41,69.49) v1(132.36,40.64) v1(132.35,20.57) v1(133.21,32.94) v1(133.23,29.38) v1(133.35,21.84) v1(133.36,40.64) v1(133.43,14.61) v1(133.46,84.58) v1(133.55,24.87) v1(133.78,54.2) v1(133.78,52.93) v1(133.78,51.26) v1(134.24,30.61) v1(134.36,40.64) v1(134.51,89.21) v1(134.46,84.58) v1(135.05,54.2) v1(135.05,52.93) v1(135.05,51.26) v1(135.31,68.83) v1(135.51,89.21) v1(135.46,84.58) v1(135.53,7.22) v1(135.94,4.14) v1(136.21,36.84) v1(136.21,34.94) v1(136.21,32.94) v1(136.32,54.2) v1(136.32,52.93) v1(136.32,51.26) v1(136.35,24.03) v1(136.35,0.79) v1(136.51,89.21) v1(136.46,84.58) v1(136.53,9.22) v1(137.06,72.62) v1(137.06,25.27) v1(137.21,36.84) v1(137.21,34.94) v1(137.21,32.94) v1(137.24,30.53) v1(137.24,29.26) v1(137.51,89.21) v1(137.59,54.2) v1(137.59,52.93) v1(137.59,51.26) v1(138.1,26.62) v1(138.21,37.84) v1(138.21,36.84) v1(138.21,34.94) v1(138.21,32.94) v1(138.33,72.62) v1(138.75,4.14) v1(138.86,54.2) v1(138.86,52.93) v1(138.86,51.26) v1(138.86,6.3) v1(139.21,38.84) v1(139.21,37.84) v1(139.21,36.84) v1(139.21,34.94) v1(139.21,33.94) v1(139.21,32.94) v1(139.28,24.85) v1(139.29,21.61) v1(139.6,72.62) v1(139.85,23.05) v1(140.21,38.84) v1(140.21,37.84) v1(140.21,34.94) v1(140.21,33.94) v1(140.21,32.94) v1(140.16,0.79) v1(140.38,28.24) v1(140.38,20.35) v1(141.12,26.05) v1(141.12,24.55) v1(141.12,23.05) v1(141.21,38.84) v1(141.21,37.84) v1(141.21,34.94) v1(141.21,33.94) v1(141.21,32.94) v1(141.32,89.21) v1(141.33,8.46) v1(141.38,28.24) v1(141.39,18.05) v1(141.39,16.05) v1(141.39,15.05) v1(141.4,10.97) v1(141.76,47.68) v1(142.21,38.84) v1(142.21,37.84) v1(142.21,36.84) v1(142.21,34.94) v1(142.21,33.94) v1(142.21,32.94) v1(142.38,28.24) v1(142.4,12.89) v1(142.95,62.87) v1(143.21,38.84) v1(143.21,37.84) v1(143.21,34.94) v1(143.21,33.94) v1(143.21,32.94) v1(143.38,28.24) v1(143.97,0.79) v1(144.21,38.84) v1(144.21,37.84) v1(144.21,34.94) v1(144.21,33.94) v1(144.21,32.94) v1(144.38,28.24) v1(145.21,38.84) v1(145.21,37.84) v1(145.21,33.94) v1(145.21,32.94) v1(146.21,32.94) v1(147.21,32.94) v1(147.78,0.93) v1(148.82,88.26) v1(149.21,84.47) v1(149.21,80.66) v1(149.21,76.85) v1(149.21,73.04) v1(149.21,69.23) v1(149.21,65.42) v1(149.21,61.61) v1(149.21,57.8) v1(149.21,53.99) v1(149.21,50.18) v1(149.21,46.37) v1(149.21,42.56) v1(149.21,38.94) v1(149.21,37.94) v1(149.21,36.94) v1(149.21,35.94) v1(149.21,34.94) v1(149.22,33.83) v1(149.21,32.94) v1(149.21,31.13) v1(149.21,30.13) v1(149.21,29.13) v1(149.21,23.51) v1(149.21,19.7) v1(149.21,15.89) v1(149.21,12.08) v1(149.21,8.27)
